simulator( 'spectreS )
