* # FILE NAME: /HOME/ECEGRID/A/559MG3/CADENCE/SIMULATION/
* HALF_ADDER_22_STATIC_CMOS/HSPICES/EXTRACTED/NETLIST/
* HALF_ADDER_22_STATIC_CMOS.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON NOV 26 16:33:44 2014

* FILE NAME: PROJ_LIB_HALF_ADDER_22_STATIC_CMOS_EXTRACTED.S.
* SUBCIRCUIT FOR CELL: HALF_ADDER_22_STATIC_CMOS.
* GENERATED FOR: HSPICES.
* GENERATED ON NOV 26 16:33:44 2014.

C14 GD 5  64.4274E-18 M=1.0
C15 GD 4  69.9273E-18 M=1.0
C16 GD 3  69.9273E-18 M=1.0
C17 GD A_IN  204.282E-18 M=1.0
C18 VD 5  33.7851E-18 M=1.0
C19 VD A_IN  74.6415E-18 M=1.0
C20 B_IN GD  248.2812E-18 M=1.0
C21 B_IN VD  40.0707E-18 M=1.0
C22 2 A_IN  454.8447E-18 M=1.0
C23 GD 5  219.5424E-18 M=1.0
C24 GD 4  189.5436E-18 M=1.0
C25 GD 3  189.5436E-18 M=1.0
C26 GD 2  181.134E-18 M=1.0
C27 VD 5  67.8456E-18 M=1.0
C28 VD 4  30.4272E-18 M=1.0
C29 VD 3  30.4272E-18 M=1.0
C30 VD A_IN  75.5838E-18 M=1.0
C31 VD 2  30.4272E-18 M=1.0
C32 B_IN 5  75.2328E-18 M=1.0
C33 B_IN GD  75.5838E-18 M=1.0
C34 1 GD  164.349E-18 M=1.0
C35 1 VD  30.4272E-18 M=1.0
C36 4 6  34.9776E-18 M=1.0
C37 3 6  34.9776E-18 M=1.0
C38 3 4  100.0224E-18 M=1.0
C39 A_IN 6  34.9776E-18 M=1.0
C40 A_IN 4  100.0224E-18 M=1.0
C41 A_IN 3  100.0224E-18 M=1.0
C42 2 6  68.7384E-18 M=1.0
C43 2 A_IN  65.0448E-18 M=1.0
C44 GD 4  146.8449E-18 M=1.0
C45 GD 3  230.8167E-18 M=1.0
C46 VD 6  65.9682E-18 M=1.0
C47 VD A_IN  527.5539E-18 M=1.0
C48 B_IN 6  34.9776E-18 M=1.0
C49 B_IN 4  100.0224E-18 M=1.0
C50 B_IN 3  69.9552E-18 M=1.0
C51 B_IN A_IN  104.9328E-18 M=1.0
C52 B_IN 2  127.7451E-18 M=1.0
C53 B_IN GD  456.8508E-18 M=1.0
M54 1 5 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M55 VD B_IN 5 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M56 5 A_IN VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M57 6 B_IN 2 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=437.400007706479E-15 PD=1.7999999499807E-6
+PS=1.07999994725105E-6 M=1
M58 2 A_IN 6 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=218.700003853239E-15 PD=1.07999994725105E-6
+PS=539.999973625527E-9 M=1
M59 6 4 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M60 VD 3 6 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M61 4 B_IN VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=1.70999999227206E-6
+PS=1.97999997908482E-6 M=1
M62 3 A_IN VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M63 1 5 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=190.350000844018E-15 PD=1.35000004775065E-6
+PS=1.62000003456342E-6 M=1
M64 5 B_IN 13 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M65 13 A_IN GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M66 GD B_IN 12 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M67 12 A_IN 2 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M68 2 4 11 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M69 11 3 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M70 4 B_IN GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M71 3 A_IN GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1

.lib "$CDK_DIR/models/hspice/public/publicModel/tsmc18dP" PMOS
.lib "$CDK_DIR/models/hspice/public/publicModel/tsmc18dN" NMOS

* INCLUDE FILES

* END OF NETLIST
.TEMP    25.0000
*.OP
*.save
*.OPTION  INGOLD=2 ARTIST=2 PSF=2
*+        PROBE=0
vVD VD 0 DC=1.8v
vGD GD 0 DC=0v
.END
