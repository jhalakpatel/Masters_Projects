* # FILE NAME: /HOME/ECEGRID/A/559MG3/CADENCE/SIMULATION/PARTIALPRODUCT64/
* HSPICES/EXTRACTED/NETLIST/PARTIALPRODUCT64.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON DEC 5 21:58:22 2014

* FILE NAME: PROJ_LIB_PARTIALPRODUCT64_EXTRACTED.S.
* SUBCIRCUIT FOR CELL: PARTIALPRODUCT64.
* GENERATED FOR: HSPICES.
* GENERATED ON DEC  5 21:58:22 2014.

C1501 GD 781  91.1411999999998E-18 M=1.0
C1502 GD 780  76.212899999999E-18 M=1.0
C1503 GD 692  69.9273000000004E-18 M=1.0
C1504 GD 691  139.854599999999E-18 M=1.0
C1505 GD 591  103.7124E-18 M=1.0
C1506 GD 560  73.0701E-18 M=1.0
C1507 GD 543  91.1412000000003E-18 M=1.0
C1508 GD 533  370.0647E-18 M=1.0
C1509 GD 511  31.82085E-18 M=1.0
C1510 GD 467  29.8566E-18 M=1.0
C1511 GD 466  23.571E-18 M=1.0
C1512 GD 444  69.9273000000001E-18 M=1.0
C1513 GD 418  70.713E-18 M=1.0
C1514 GD 417  76.2128999999992E-18 M=1.0
C1515 GD 348  76.2129E-18 M=1.0
C1516 GD 347  70.713E-18 M=1.0
C1517 GD 329  282.852000000001E-18 M=1.0
C1518 GD 324  209.781900000001E-18 M=1.0
C1519 GD 322  139.8546E-18 M=1.0
C1520 GD 316  254.5668E-18 M=1.0
C1521 GD 289  69.9273E-18 M=1.0
C1522 GD 279  209.781900000001E-18 M=1.0
C1523 GD 277  139.8546E-18 M=1.0
C1524 GD 275  69.9273E-18 M=1.0
C1525 GD 273  254.5668E-18 M=1.0
C1526 GD 272  209.7819E-18 M=1.0
C1527 GD 271  139.8546E-18 M=1.0
C1528 GD 269  69.9273000000003E-18 M=1.0
C1529 GD 265  139.8546E-18 M=1.0
C1530 GD 263  69.9272999999999E-18 M=1.0
C1531 GD 261  282.852E-18 M=1.0
C1532 GD 259  139.8546E-18 M=1.0
C1533 GD 257  69.9273000000005E-18 M=1.0
C1534 GD 253  139.854600000001E-18 M=1.0
C1535 GD 251  69.9273000000001E-18 M=1.0
C1536 GD 247  282.852000000001E-18 M=1.0
C1537 GD 240  139.854600000004E-18 M=1.0
C1538 GD 238  69.9273000000016E-18 M=1.0
C1539 GD 234  69.9273E-18 M=1.0
C1540 GD 233  69.9273E-18 M=1.0
C1541 GD 232  139.8546E-18 M=1.0
C1542 GD 230  69.9273E-18 M=1.0
C1543 GD 228  254.566800000001E-18 M=1.0
C1544 GD 226  139.8546E-18 M=1.0
C1545 GD 224  69.9273000000003E-18 M=1.0
C1546 GD 221  282.852E-18 M=1.0
C1547 GD 220  139.8546E-18 M=1.0
C1548 GD 218  69.9272999999999E-18 M=1.0
C1549 GD 216  254.5668E-18 M=1.0
C1550 GD 215  209.7819E-18 M=1.0
C1551 GD 214  139.854600000001E-18 M=1.0
C1552 GD 212  69.9273000000001E-18 M=1.0
C1553 GD 210  254.566800000002E-18 M=1.0
C1554 GD 209  209.781899999999E-18 M=1.0
C1555 GD 208  139.8546E-18 M=1.0
C1556 GD 206  69.9273000000005E-18 M=1.0
C1557 GD 203  282.852E-18 M=1.0
C1558 GD 200  139.8546E-18 M=1.0
C1559 GD 199  139.8546E-18 M=1.0
C1560 GD 191  254.5668E-18 M=1.0
C1561 GD 190  282.851999999999E-18 M=1.0
C1562 GD 187  209.7819E-18 M=1.0
C1563 GD 185  209.781899999998E-18 M=1.0
C1564 GD 180  254.566800000002E-18 M=1.0
C1565 GD 174  209.781899999999E-18 M=1.0
C1566 GD 173  209.7819E-18 M=1.0
C1567 GD 166  282.851999999999E-18 M=1.0
C1568 GD 147  254.566800000001E-18 M=1.0
C1569 GD 145  254.5668E-18 M=1.0
C1570 GD 144  254.566799999999E-18 M=1.0
C1571 GD 137  209.781899999998E-18 M=1.0
C1572 GD 135  209.781899999999E-18 M=1.0
C1573 GD 134  209.7819E-18 M=1.0
C1574 GD 133  209.781900000003E-18 M=1.0
C1575 GD 113  209.7819E-18 M=1.0
C1576 GD 112  209.781900000003E-18 M=1.0
C1577 GD 103  254.5668E-18 M=1.0
C1578 GD 37  282.851999999996E-18 M=1.0
C1579 GD 25  254.5668E-18 M=1.0
C1580 GD 6  254.566800000003E-18 M=1.0
C1581 A6B4 GD  282.852E-18 M=1.0
C1582 VD 691  26.7138000000001E-18 M=1.0
C1583 VD 387  106.855200000001E-18 M=1.0
C1584 VD 329  53.4276E-18 M=1.0
C1585 VD 324  40.0706999999998E-18 M=1.0
C1586 VD 316  81.7127999999999E-18 M=1.0
C1587 VD 287  26.7138000000004E-18 M=1.0
C1588 VD 277  26.7138000000001E-18 M=1.0
C1589 VD 273  81.7128E-18 M=1.0
C1590 VD 272  40.0706999999999E-18 M=1.0
C1591 VD 271  26.7137999999999E-18 M=1.0
C1592 VD 265  26.7138E-18 M=1.0
C1593 VD 261  53.4275999999998E-18 M=1.0
C1594 VD 259  26.7138000000001E-18 M=1.0
C1595 VD 253  26.7137999999998E-18 M=1.0
C1596 VD 247  53.4276000000001E-18 M=1.0
C1597 VD 240  26.7138000000004E-18 M=1.0
C1598 VD 228  81.7128E-18 M=1.0
C1599 VD 221  53.4276E-18 M=1.0
C1600 VD 216  81.7128000000001E-18 M=1.0
C1601 VD 215  40.0707E-18 M=1.0
C1602 VD 210  81.7128000000003E-18 M=1.0
C1603 VD 209  40.0707E-18 M=1.0
C1604 VD 203  53.4275999999999E-18 M=1.0
C1605 VD 200  26.7138E-18 M=1.0
C1606 VD 199  26.7138000000002E-18 M=1.0
C1607 VD 190  53.4276E-18 M=1.0
C1608 VD 185  40.0707E-18 M=1.0
C1609 VD 174  40.0707E-18 M=1.0
C1610 VD 166  53.4276000000004E-18 M=1.0
C1611 VD 165  53.4276E-18 M=1.0
C1612 VD 143  81.7128000000001E-18 M=1.0
C1613 VD 135  40.0707E-18 M=1.0
C1614 VD 134  40.0707000000003E-18 M=1.0
C1615 VD 133  40.0706999999999E-18 M=1.0
C1616 VD 113  40.0707E-18 M=1.0
C1617 VD 7  81.7127999999998E-18 M=1.0
C1618 VD 6  81.7128000000001E-18 M=1.0
C1619 A7B3 GD  254.5668E-18 M=1.0
C1620 A7B3 VD  81.7127999999998E-18 M=1.0
C1621 779 780  171.7443E-18 M=1.0
C1622 466 467  75.2328E-18 M=1.0
C1623 417 418  171.7443E-18 M=1.0
C1624 387 418  75.2328E-18 M=1.0
C1625 347 369  75.2328E-18 M=1.0
C1626 347 348  171.7443E-18 M=1.0
C1627 GD 781  202.6413E-18 M=1.0
C1628 GD 780  226.8738E-18 M=1.0
C1629 GD 695  164.349E-18 M=1.0
C1630 GD 692  189.5436E-18 M=1.0
C1631 GD 634  164.349E-18 M=1.0
C1632 GD 560  282.8808E-18 M=1.0
C1633 GD 444  189.5436E-18 M=1.0
C1634 GD 418  250.7832E-18 M=1.0
C1635 GD 417  226.8738E-18 M=1.0
C1636 GD 416  202.6413E-18 M=1.0
C1637 GD 387  364.212E-18 M=1.0
C1638 GD 348  226.8738E-18 M=1.0
C1639 GD 324  239.9328E-18 M=1.0
C1640 GD 301  189.5436E-18 M=1.0
C1641 GD 285  189.543599999999E-18 M=1.0
C1642 GD 283  236.745000000001E-18 M=1.0
C1643 GD 279  239.9328E-18 M=1.0
C1644 GD 277  214.7382E-18 M=1.0
C1645 GD 276  44.0136E-18 M=1.0
C1646 GD 275  189.5436E-18 M=1.0
C1647 GD 274  44.0136E-18 M=1.0
C1648 GD 273  164.349E-18 M=1.0
C1649 GD 272  239.9328E-18 M=1.0
C1650 GD 271  214.7382E-18 M=1.0
C1651 GD 270  44.0136E-18 M=1.0
C1652 GD 269  189.5436E-18 M=1.0
C1653 GD 268  44.0136E-18 M=1.0
C1654 GD 267  164.349E-18 M=1.0
C1655 GD 265  214.7382E-18 M=1.0
C1656 GD 264  44.0136E-18 M=1.0
C1657 GD 263  189.5436E-18 M=1.0
C1658 GD 262  44.0136E-18 M=1.0
C1659 GD 259  214.7382E-18 M=1.0
C1660 GD 258  44.0136E-18 M=1.0
C1661 GD 257  189.5436E-18 M=1.0
C1662 GD 256  44.0136E-18 M=1.0
C1663 GD 255  164.349E-18 M=1.0
C1664 GD 254  239.9328E-18 M=1.0
C1665 GD 253  214.7382E-18 M=1.0
C1666 GD 252  44.0136E-18 M=1.0
C1667 GD 251  189.5436E-18 M=1.0
C1668 GD 250  44.0136E-18 M=1.0
C1669 GD 249  164.349E-18 M=1.0
C1670 GD 247  236.745E-18 M=1.0
C1671 GD 245  164.349E-18 M=1.0
C1672 GD 244  164.349E-18 M=1.0
C1673 GD 242  44.0136E-18 M=1.0
C1674 GD 241  44.0135999999999E-18 M=1.0
C1675 GD 240  214.738200000001E-18 M=1.0
C1676 GD 239  44.0136E-18 M=1.0
C1677 GD 238  189.543599999999E-18 M=1.0
C1678 GD 237  44.0135999999999E-18 M=1.0
C1679 GD 236  164.349000000001E-18 M=1.0
C1680 GD 234  189.5436E-18 M=1.0
C1681 GD 233  189.5436E-18 M=1.0
C1682 GD 232  214.7382E-18 M=1.0
C1683 GD 231  44.0136E-18 M=1.0
C1684 GD 230  189.5436E-18 M=1.0
C1685 GD 229  44.0136E-18 M=1.0
C1686 GD 228  164.349E-18 M=1.0
C1687 GD 226  214.7382E-18 M=1.0
C1688 GD 225  44.0136E-18 M=1.0
C1689 GD 224  189.5436E-18 M=1.0
C1690 GD 223  44.0136E-18 M=1.0
C1691 GD 221  236.745E-18 M=1.0
C1692 GD 220  214.7382E-18 M=1.0
C1693 GD 219  44.0136E-18 M=1.0
C1694 GD 218  189.5436E-18 M=1.0
C1695 GD 217  44.0136E-18 M=1.0
C1696 GD 216  164.349E-18 M=1.0
C1697 GD 215  239.9328E-18 M=1.0
C1698 GD 214  214.7382E-18 M=1.0
C1699 GD 213  44.0136E-18 M=1.0
C1700 GD 212  189.5436E-18 M=1.0
C1701 GD 211  44.0136E-18 M=1.0
C1702 GD 210  164.349E-18 M=1.0
C1703 GD 209  239.9328E-18 M=1.0
C1704 GD 208  214.7382E-18 M=1.0
C1705 GD 207  44.0136E-18 M=1.0
C1706 GD 206  189.5436E-18 M=1.0
C1707 GD 205  44.0136E-18 M=1.0
C1708 GD 203  236.745E-18 M=1.0
C1709 GD 201  44.0136E-18 M=1.0
C1710 GD 200  214.7382E-18 M=1.0
C1711 GD 199  214.7382E-18 M=1.0
C1712 GD 190  236.745E-18 M=1.0
C1713 GD 187  256.7178E-18 M=1.0
C1714 GD 185  239.9328E-18 M=1.0
C1715 GD 176  189.5436E-18 M=1.0
C1716 GD 174  239.9328E-18 M=1.0
C1717 GD 137  136.2294E-18 M=1.0
C1718 GD 135  136.2294E-18 M=1.0
C1719 GD 134  136.2294E-18 M=1.0
C1720 GD 133  136.2294E-18 M=1.0
C1721 GD 113  136.2294E-18 M=1.0
C1722 GD 37  133.0416E-18 M=1.0
C1723 A_4 347  75.2328E-18 M=1.0
C1724 A6B4 GD  133.0416E-18 M=1.0
C1725 VD 781  30.4272E-18 M=1.0
C1726 VD 542  30.4272E-18 M=1.0
C1727 VD 417  30.4272E-18 M=1.0
C1728 VD 416  30.4272E-18 M=1.0
C1729 VD 349  30.4272E-18 M=1.0
C1730 VD 348  30.4272E-18 M=1.0
C1731 VD 316  102.8232E-18 M=1.0
C1732 VD 301  30.4272E-18 M=1.0
C1733 VD 287  30.4271999999998E-18 M=1.0
C1734 VD 285  30.4272000000001E-18 M=1.0
C1735 VD 283  30.4271999999998E-18 M=1.0
C1736 VD 282  30.4272000000001E-18 M=1.0
C1737 VD 277  30.4272000000001E-18 M=1.0
C1738 VD 275  30.4271999999999E-18 M=1.0
C1739 VD 273  102.8232E-18 M=1.0
C1740 VD 272  30.4272E-18 M=1.0
C1741 VD 271  30.4272E-18 M=1.0
C1742 VD 269  30.4272E-18 M=1.0
C1743 VD 266  30.4272E-18 M=1.0
C1744 VD 265  30.4272E-18 M=1.0
C1745 VD 263  30.4272E-18 M=1.0
C1746 VD 261  30.4272E-18 M=1.0
C1747 VD 260  30.4272E-18 M=1.0
C1748 VD 259  30.4272E-18 M=1.0
C1749 VD 257  30.4272E-18 M=1.0
C1750 VD 255  102.8232E-18 M=1.0
C1751 VD 254  30.4271999999999E-18 M=1.0
C1752 VD 253  30.4271999999999E-18 M=1.0
C1753 VD 251  30.4271999999999E-18 M=1.0
C1754 VD 249  102.8232E-18 M=1.0
C1755 VD 248  30.4272000000001E-18 M=1.0
C1756 VD 247  30.4271999999999E-18 M=1.0
C1757 VD 246  30.4272000000001E-18 M=1.0
C1758 VD 243  30.4271999999999E-18 M=1.0
C1759 VD 240  30.4271999999998E-18 M=1.0
C1760 VD 238  30.4272000000001E-18 M=1.0
C1761 VD 236  102.8232E-18 M=1.0
C1762 VD 235  30.4272000000001E-18 M=1.0
C1763 VD 234  30.4271999999999E-18 M=1.0
C1764 VD 233  30.4272000000001E-18 M=1.0
C1765 VD 216  102.8232E-18 M=1.0
C1766 VD 210  102.8232E-18 M=1.0
C1767 VD 206  30.4272E-18 M=1.0
C1768 VD 202  30.4271999999999E-18 M=1.0
C1769 VD 200  30.4271999999999E-18 M=1.0
C1770 VD 199  30.4272000000001E-18 M=1.0
C1771 VD 176  30.4272E-18 M=1.0
C1772 VD 143  106.626599999999E-18 M=1.0
C1773 VD 6  106.626599999999E-18 M=1.0
C1774 VD GD  49.6433978999999E-15 M=1.0
C1775 VD A_4  20.4129E-18 M=1.0
C1776 VD S_7  30.4272E-18 M=1.0
C1777 A7B3 VD  106.6266E-18 M=1.0
C1778 722 780  74.9664E-18 M=1.0
C1779 722 779  117.0432E-18 M=1.0
C1780 691 694  65.0448E-18 M=1.0
C1781 560 591  211.34925E-18 M=1.0
C1782 444 533  69.9552E-18 M=1.0
C1783 387 418  117.0432E-18 M=1.0
C1784 387 417  74.9664E-18 M=1.0
C1785 348 369  74.9664E-18 M=1.0
C1786 347 369  117.0432E-18 M=1.0
C1787 329 821  34.9776E-18 M=1.0
C1788 324 821  34.9776E-18 M=1.0
C1789 324 820  34.9776E-18 M=1.0
C1790 324 329  174.888E-18 M=1.0
C1791 316 827  69.9552E-18 M=1.0
C1792 316 826  34.9776E-18 M=1.0
C1793 287 833  69.2001000000001E-18 M=1.0
C1794 278 279  174.888E-18 M=1.0
C1795 277 829  69.2001E-18 M=1.0
C1796 276 277  69.2001E-18 M=1.0
C1797 275 277  135E-18 M=1.0
C1798 273 825  69.9552E-18 M=1.0
C1799 273 824  34.9776E-18 M=1.0
C1800 273 277  65.0448E-18 M=1.0
C1801 272 827  34.9776E-18 M=1.0
C1802 272 826  34.9776E-18 M=1.0
C1803 272 316  139.9104E-18 M=1.0
C1804 271 827  69.2001E-18 M=1.0
C1805 271 316  169.9776E-18 M=1.0
C1806 271 272  139.9104E-18 M=1.0
C1807 270 316  69.9552E-18 M=1.0
C1808 270 272  34.9776E-18 M=1.0
C1809 270 271  69.2001E-18 M=1.0
C1810 269 316  100.0224E-18 M=1.0
C1811 269 272  100.0224E-18 M=1.0
C1812 269 271  135E-18 M=1.0
C1813 268 316  34.9776E-18 M=1.0
C1814 268 272  34.9776E-18 M=1.0
C1815 267 271  65.0448E-18 M=1.0
C1816 265 825  69.2001E-18 M=1.0
C1817 265 273  169.9776E-18 M=1.0
C1818 264 273  69.9552E-18 M=1.0
C1819 264 265  69.2001E-18 M=1.0
C1820 263 273  100.0224E-18 M=1.0
C1821 263 265  135E-18 M=1.0
C1822 262 273  34.9776E-18 M=1.0
C1823 261 317  174.888E-18 M=1.0
C1824 261 303  204.9552E-18 M=1.0
C1825 261 265  65.0448E-18 M=1.0
C1826 259 823  69.2001E-18 M=1.0
C1827 258 259  69.2001E-18 M=1.0
C1828 257 259  135E-18 M=1.0
C1829 255 259  65.0448E-18 M=1.0
C1830 253 821  69.2001E-18 M=1.0
C1831 253 329  204.9552E-18 M=1.0
C1832 253 324  139.9104E-18 M=1.0
C1833 252 329  34.9776E-18 M=1.0
C1834 252 324  34.9776E-18 M=1.0
C1835 252 253  69.2001E-18 M=1.0
C1836 251 329  100.0224E-18 M=1.0
C1837 251 324  100.0224E-18 M=1.0
C1838 251 253  135E-18 M=1.0
C1839 250 324  34.9776E-18 M=1.0
C1840 249 253  65.0448E-18 M=1.0
C1841 247 827  34.9776E-18 M=1.0
C1842 247 322  65.0448E-18 M=1.0
C1843 247 316  174.888E-18 M=1.0
C1844 247 272  174.888E-18 M=1.0
C1845 247 271  204.9552E-18 M=1.0
C1846 247 270  34.9776E-18 M=1.0
C1847 247 269  100.0224E-18 M=1.0
C1848 240 818  69.2001000000001E-18 M=1.0
C1849 239 240  69.2001000000001E-18 M=1.0
C1850 238 240  135E-18 M=1.0
C1851 236 240  65.0448E-18 M=1.0
C1852 231 232  69.2001E-18 M=1.0
C1853 230 232  135E-18 M=1.0
C1854 228 829  69.9552E-18 M=1.0
C1855 228 828  34.9776E-18 M=1.0
C1856 228 277  169.9776E-18 M=1.0
C1857 228 276  69.9552E-18 M=1.0
C1858 228 275  100.0224E-18 M=1.0
C1859 228 274  34.9776E-18 M=1.0
C1860 228 232  65.0448E-18 M=1.0
C1861 225 226  69.2001E-18 M=1.0
C1862 224 226  135E-18 M=1.0
C1863 222 226  65.0448E-18 M=1.0
C1864 221 825  34.9776E-18 M=1.0
C1865 221 273  174.888E-18 M=1.0
C1866 221 265  204.9552E-18 M=1.0
C1867 221 264  34.9776E-18 M=1.0
C1868 221 263  100.0224E-18 M=1.0
C1869 219 220  69.2001E-18 M=1.0
C1870 218 220  135E-18 M=1.0
C1871 216 823  69.9552E-18 M=1.0
C1872 216 822  34.9776E-18 M=1.0
C1873 216 259  169.9776E-18 M=1.0
C1874 216 258  69.9552E-18 M=1.0
C1875 216 257  100.0224E-18 M=1.0
C1876 216 256  34.9776E-18 M=1.0
C1877 216 220  65.0448E-18 M=1.0
C1878 215 825  34.9776E-18 M=1.0
C1879 215 824  34.9776E-18 M=1.0
C1880 215 273  139.9104E-18 M=1.0
C1881 215 265  139.9104E-18 M=1.0
C1882 215 264  34.9776E-18 M=1.0
C1883 215 263  100.0224E-18 M=1.0
C1884 215 262  34.9776E-18 M=1.0
C1885 215 221  174.888E-18 M=1.0
C1886 214 279  139.9104E-18 M=1.0
C1887 214 278  204.9552E-18 M=1.0
C1888 213 279  34.9776E-18 M=1.0
C1889 213 278  34.9776E-18 M=1.0
C1890 213 214  69.2001E-18 M=1.0
C1891 212 279  100.0224E-18 M=1.0
C1892 212 278  100.0224E-18 M=1.0
C1893 212 214  135E-18 M=1.0
C1894 211 279  34.9776E-18 M=1.0
C1895 210 821  69.9552E-18 M=1.0
C1896 210 820  34.9776E-18 M=1.0
C1897 210 329  174.888E-18 M=1.0
C1898 210 324  139.9104E-18 M=1.0
C1899 210 253  169.9776E-18 M=1.0
C1900 210 252  69.9552E-18 M=1.0
C1901 210 251  100.0224E-18 M=1.0
C1902 210 250  34.9776E-18 M=1.0
C1903 210 214  65.0448E-18 M=1.0
C1904 209 823  34.9776E-18 M=1.0
C1905 209 822  34.9776E-18 M=1.0
C1906 209 259  139.9104E-18 M=1.0
C1907 209 258  34.9776E-18 M=1.0
C1908 209 257  100.0224E-18 M=1.0
C1909 209 256  34.9776E-18 M=1.0
C1910 209 216  139.9104E-18 M=1.0
C1911 207 208  69.2001E-18 M=1.0
C1912 206 208  135E-18 M=1.0
C1913 204 208  65.0448E-18 M=1.0
C1914 203 823  34.9776E-18 M=1.0
C1915 203 259  204.9552E-18 M=1.0
C1916 203 258  34.9776E-18 M=1.0
C1917 203 257  100.0224E-18 M=1.0
C1918 203 216  174.888E-18 M=1.0
C1919 203 209  174.888E-18 M=1.0
C1920 202 819  69.2001E-18 M=1.0
C1921 201 202  69.2001E-18 M=1.0
C1922 200 806  69.2001000000001E-18 M=1.0
C1923 200 245  65.0448E-18 M=1.0
C1924 200 234  135E-18 M=1.0
C1925 199 805  69.2001000000001E-18 M=1.0
C1926 199 244  65.0448000000001E-18 M=1.0
C1927 199 233  135E-18 M=1.0
C1928 198 200  69.2001000000001E-18 M=1.0
C1929 196 199  69.2001E-18 M=1.0
C1930 191 219  69.9552E-18 M=1.0
C1931 191 218  100.0224E-18 M=1.0
C1932 191 217  34.9776E-18 M=1.0
C1933 190 829  34.9776E-18 M=1.0
C1934 190 277  204.9552E-18 M=1.0
C1935 190 276  34.9776E-18 M=1.0
C1936 190 275  100.0224E-18 M=1.0
C1937 190 228  174.888E-18 M=1.0
C1938 187 226  139.9104E-18 M=1.0
C1939 187 225  34.9776E-18 M=1.0
C1940 187 224  100.0224E-18 M=1.0
C1941 187 223  34.9776E-18 M=1.0
C1942 185 829  34.9776E-18 M=1.0
C1943 185 828  34.9776E-18 M=1.0
C1944 185 277  139.9104E-18 M=1.0
C1945 185 276  34.9776E-18 M=1.0
C1946 185 275  100.0224E-18 M=1.0
C1947 185 274  34.9776E-18 M=1.0
C1948 185 228  139.9104E-18 M=1.0
C1949 185 190  174.888E-18 M=1.0
C1950 180 214  169.9776E-18 M=1.0
C1951 180 213  69.9552E-18 M=1.0
C1952 180 212  100.0224E-18 M=1.0
C1953 180 211  34.9776E-18 M=1.0
C1954 179 220  204.9552E-18 M=1.0
C1955 179 219  34.9776E-18 M=1.0
C1956 179 218  100.0224E-18 M=1.0
C1957 174 208  139.9104E-18 M=1.0
C1958 174 207  34.9776E-18 M=1.0
C1959 174 206  100.0224E-18 M=1.0
C1960 174 205  34.9776E-18 M=1.0
C1961 173 220  139.9104E-18 M=1.0
C1962 173 219  34.9776E-18 M=1.0
C1963 173 218  100.0224E-18 M=1.0
C1964 173 217  34.9776E-18 M=1.0
C1965 169 231  34.9776E-18 M=1.0
C1966 169 230  100.0224E-18 M=1.0
C1967 166 233  100.0224E-18 M=1.0
C1968 166 199  204.9552E-18 M=1.0
C1969 165 833  34.9776E-18 M=1.0
C1970 147 231  69.9552E-18 M=1.0
C1971 147 230  100.0224E-18 M=1.0
C1972 147 229  34.9776E-18 M=1.0
C1973 145 167  174.888E-18 M=1.0
C1974 144 830  34.9776E-18 M=1.0
C1975 144 241  34.9776E-18 M=1.0
C1976 144 233  100.0224E-18 M=1.0
C1977 144 199  169.9776E-18 M=1.0
C1978 143 833  69.9552000000001E-18 M=1.0
C1979 143 832  34.9776E-18 M=1.0
C1980 143 165  174.888E-18 M=1.0
C1981 138 819  34.9776E-18 M=1.0
C1982 138 202  139.9104E-18 M=1.0
C1983 138 201  34.9776E-18 M=1.0
C1984 137 232  139.9104E-18 M=1.0
C1985 137 231  34.9776E-18 M=1.0
C1986 137 230  100.0224E-18 M=1.0
C1987 137 229  34.9776E-18 M=1.0
C1988 135 167  174.888E-18 M=1.0
C1989 134 830  34.9776E-18 M=1.0
C1990 134 805  34.9776E-18 M=1.0
C1991 134 241  34.9776E-18 M=1.0
C1992 134 233  100.0224E-18 M=1.0
C1993 134 199  139.9104E-18 M=1.0
C1994 134 196  34.9776E-18 M=1.0
C1995 134 166  174.888E-18 M=1.0
C1996 134 144  139.9104E-18 M=1.0
C1997 133 833  34.9776E-18 M=1.0
C1998 133 832  34.9776E-18 M=1.0
C1999 133 165  174.888E-18 M=1.0
C2000 133 143  139.9104E-18 M=1.0
C2001 113 831  34.9776E-18 M=1.0
C2002 113 806  34.9776E-18 M=1.0
C2003 113 242  34.9776E-18 M=1.0
C2004 113 234  100.0224E-18 M=1.0
C2005 113 200  139.9104E-18 M=1.0
C2006 113 198  34.9776E-18 M=1.0
C2007 112 818  34.9776E-18 M=1.0
C2008 112 817  34.9776E-18 M=1.0
C2009 112 240  139.9104E-18 M=1.0
C2010 112 239  34.9776E-18 M=1.0
C2011 112 238  100.0224E-18 M=1.0
C2012 112 237  34.9776E-18 M=1.0
C2013 103 226  169.9776E-18 M=1.0
C2014 103 225  69.9552E-18 M=1.0
C2015 103 224  100.0224E-18 M=1.0
C2016 103 223  34.9776E-18 M=1.0
C2017 102 208  204.9552E-18 M=1.0
C2018 102 207  34.9776E-18 M=1.0
C2019 102 206  100.0224E-18 M=1.0
C2020 38 234  100.0224E-18 M=1.0
C2021 38 200  204.9552E-18 M=1.0
C2022 38 113  174.888E-18 M=1.0
C2023 37 818  34.9776E-18 M=1.0
C2024 37 240  204.9552E-18 M=1.0
C2025 37 239  34.9776E-18 M=1.0
C2026 37 238  100.0224E-18 M=1.0
C2027 37 112  174.888E-18 M=1.0
C2028 26 225  34.9776E-18 M=1.0
C2029 26 224  100.0224E-18 M=1.0
C2030 25 207  69.9552E-18 M=1.0
C2031 25 206  100.0224E-18 M=1.0
C2032 25 205  34.9776E-18 M=1.0
C2033 25 174  139.9104E-18 M=1.0
C2034 25 102  174.888E-18 M=1.0
C2035 7 831  34.9776E-18 M=1.0
C2036 7 242  34.9776E-18 M=1.0
C2037 7 234  100.0224E-18 M=1.0
C2038 7 200  169.9776E-18 M=1.0
C2039 7 113  139.9104E-18 M=1.0
C2040 7 38  174.888E-18 M=1.0
C2041 6 818  69.9552000000001E-18 M=1.0
C2042 6 817  34.9776E-18 M=1.0
C2043 6 240  169.9776E-18 M=1.0
C2044 6 239  69.9552000000001E-18 M=1.0
C2045 6 238  100.0224E-18 M=1.0
C2046 6 237  34.9776E-18 M=1.0
C2047 6 112  139.9104E-18 M=1.0
C2048 6 37  174.888E-18 M=1.0
C2049 GD 591  1.4905539E-15 M=1.0
C2050 GD 444  236.2554E-18 M=1.0
C2051 GD 431  6.48416475E-15 M=1.0
C2052 GD 342  21.6434511E-15 M=1.0
C2053 GD 329  623.8467E-18 M=1.0
C2054 GD 324  397.0251E-18 M=1.0
C2055 GD 279  397.0251E-18 M=1.0
C2056 GD 277  799.4889E-18 M=1.0
C2057 GD 276  66.4299E-18 M=1.0
C2058 GD 275  326.322E-18 M=1.0
C2059 GD 274  65.9682E-18 M=1.0
C2060 GD 272  397.0251E-18 M=1.0
C2061 GD 271  799.4889E-18 M=1.0
C2062 GD 270  66.4299E-18 M=1.0
C2063 GD 269  326.322E-18 M=1.0
C2064 GD 268  65.9682E-18 M=1.0
C2065 GD 265  799.4889E-18 M=1.0
C2066 GD 264  66.4299E-18 M=1.0
C2067 GD 263  326.322E-18 M=1.0
C2068 GD 262  65.9682E-18 M=1.0
C2069 GD 259  799.4889E-18 M=1.0
C2070 GD 258  66.4299E-18 M=1.0
C2071 GD 257  326.322E-18 M=1.0
C2072 GD 256  65.9682E-18 M=1.0
C2073 GD 253  799.4889E-18 M=1.0
C2074 GD 252  66.4299E-18 M=1.0
C2075 GD 251  326.322E-18 M=1.0
C2076 GD 250  65.9682E-18 M=1.0
C2077 GD 247  623.8467E-18 M=1.0
C2078 GD 242  65.9682000000001E-18 M=1.0
C2079 GD 241  65.9682E-18 M=1.0
C2080 GD 240  799.4889E-18 M=1.0
C2081 GD 239  66.4299000000001E-18 M=1.0
C2082 GD 238  326.322E-18 M=1.0
C2083 GD 237  65.9682E-18 M=1.0
C2084 GD 234  326.322E-18 M=1.0
C2085 GD 233  326.322E-18 M=1.0
C2086 GD 232  799.4889E-18 M=1.0
C2087 GD 231  66.4299E-18 M=1.0
C2088 GD 230  326.322E-18 M=1.0
C2089 GD 229  65.9682E-18 M=1.0
C2090 GD 226  799.4889E-18 M=1.0
C2091 GD 225  66.4299E-18 M=1.0
C2092 GD 224  326.322E-18 M=1.0
C2093 GD 223  65.9682E-18 M=1.0
C2094 GD 221  623.8467E-18 M=1.0
C2095 GD 220  799.4889E-18 M=1.0
C2096 GD 219  66.4299E-18 M=1.0
C2097 GD 218  326.322E-18 M=1.0
C2098 GD 217  65.9682E-18 M=1.0
C2099 GD 215  397.0251E-18 M=1.0
C2100 GD 214  799.4889E-18 M=1.0
C2101 GD 213  66.4299E-18 M=1.0
C2102 GD 212  326.322E-18 M=1.0
C2103 GD 211  65.9682E-18 M=1.0
C2104 GD 209  397.0251E-18 M=1.0
C2105 GD 208  799.4889E-18 M=1.0
C2106 GD 207  66.4299E-18 M=1.0
C2107 GD 206  326.322E-18 M=1.0
C2108 GD 205  65.9682E-18 M=1.0
C2109 GD 203  623.8467E-18 M=1.0
C2110 GD 201  66.4299E-18 M=1.0
C2111 GD 200  799.4889E-18 M=1.0
C2112 GD 199  799.4889E-18 M=1.0
C2113 GD 190  623.8467E-18 M=1.0
C2114 GD 187  397.0251E-18 M=1.0
C2115 GD 185  397.0251E-18 M=1.0
C2116 GD 174  397.0251E-18 M=1.0
C2117 GD 173  397.0251E-18 M=1.0
C2118 GD 167  623.8467E-18 M=1.0
C2119 GD 166  1.9398663E-15 M=1.0
C2120 GD 165  1.7060022E-15 M=1.0
C2121 GD 137  3.9809826E-15 M=1.0
C2122 GD 134  3.2902677E-15 M=1.0
C2123 GD 113  7.16262209999999E-15 M=1.0
C2124 GD 112  7.1843769E-15 M=1.0
C2125 GD 102  623.8467E-18 M=1.0
C2126 GD 38  9.26035650000001E-15 M=1.0
C2127 GD 37  9.4343949E-15 M=1.0
C2128 A6B4 819  34.9776E-18 M=1.0
C2129 A6B4 202  204.9552E-18 M=1.0
C2130 A6B4 201  34.9776E-18 M=1.0
C2131 VD 833  66.4299000000001E-18 M=1.0
C2132 VD 832  65.9682E-18 M=1.0
C2133 VD 831  65.9682000000001E-18 M=1.0
C2134 VD 830  65.9682000000001E-18 M=1.0
C2135 VD 829  66.4299E-18 M=1.0
C2136 VD 828  65.9682E-18 M=1.0
C2137 VD 827  66.4299E-18 M=1.0
C2138 VD 826  65.9682E-18 M=1.0
C2139 VD 825  66.4299E-18 M=1.0
C2140 VD 824  65.9682E-18 M=1.0
C2141 VD 823  66.4299E-18 M=1.0
C2142 VD 822  65.9682E-18 M=1.0
C2143 VD 821  66.4299E-18 M=1.0
C2144 VD 820  65.9682E-18 M=1.0
C2145 VD 819  66.4299000000001E-18 M=1.0
C2146 VD 818  66.4299000000001E-18 M=1.0
C2147 VD 817  65.9682E-18 M=1.0
C2148 VD 403  708.7275E-18 M=1.0
C2149 VD 317  689.1111E-18 M=1.0
C2150 VD 316  689.1111E-18 M=1.0
C2151 VD 273  689.1111E-18 M=1.0
C2152 VD 228  689.1111E-18 M=1.0
C2153 VD 216  689.1111E-18 M=1.0
C2154 VD 210  689.1111E-18 M=1.0
C2155 VD 144  689.1111E-18 M=1.0
C2156 VD 143  689.1111E-18 M=1.0
C2157 VD 101  302.4153E-18 M=1.0
C2158 VD 25  689.1111E-18 M=1.0
C2159 VD 7  689.1111E-18 M=1.0
C2160 VD 6  689.1111E-18 M=1.0
C2161 CLK 542  65.0448E-18 M=1.0
C2162 A7B3 819  69.9552E-18 M=1.0
C2163 A7B3 201  69.9552E-18 M=1.0
C2164 A7B3 138  139.9104E-18 M=1.0
C2165 A7B3 VD  689.1111E-18 M=1.0
C2166 722 781  69.741E-18 M=1.0
C2167 694 781  70.6887E-18 M=1.0
C2168 694 780  105.999075E-18 M=1.0
C2169 694 721  61.5321E-18 M=1.0
C2170 593 695  61.5321E-18 M=1.0
C2171 593 694  61.5321E-18 M=1.0
C2172 570 591  103.5792E-18 M=1.0
C2173 566 570  25.6374E-18 M=1.0
C2174 560 570  36.426375E-18 M=1.0
C2175 542 570  47.5848E-18 M=1.0
C2176 538 590  279.045E-18 M=1.0
C2177 529 538  66.1824E-18 M=1.0
C2178 467 533  61.938E-18 M=1.0
C2179 467 477  43.9335E-18 M=1.0
C2180 466 467  79.81695E-18 M=1.0
C2181 324 821  52.6203E-18 M=1.0
C2182 324 407  52.3044E-18 M=1.0
C2183 324 329  52.3044E-18 M=1.0
C2184 316 427  52.3044E-18 M=1.0
C2185 299 417  70.0569E-18 M=1.0
C2186 299 416  70.0569E-18 M=1.0
C2187 298 417  79.8939E-18 M=1.0
C2188 298 416  75.861E-18 M=1.0
C2189 293 418  211.437E-18 M=1.0
C2190 293 417  44.1036E-18 M=1.0
C2191 293 416  69.741E-18 M=1.0
C2192 283 285  51.43365E-18 M=1.0
C2193 282 285  70.6887E-18 M=1.0
C2194 282 283  364.7709E-18 M=1.0
C2195 278 338  52.3044E-18 M=1.0
C2196 273 825  52.6203E-18 M=1.0
C2197 273 431  52.3044E-18 M=1.0
C2198 273 427  52.3044E-18 M=1.0
C2199 273 423  52.3044E-18 M=1.0
C2200 273 362  52.3044E-18 M=1.0
C2201 273 358  52.3044E-18 M=1.0
C2202 273 354  52.3044E-18 M=1.0
C2203 272 827  385.08345E-18 M=1.0
C2204 272 431  52.3044E-18 M=1.0
C2205 272 427  52.3044E-18 M=1.0
C2206 272 362  52.3044E-18 M=1.0
C2207 272 316  72.756E-18 M=1.0
C2208 267 423  693.0297E-18 M=1.0
C2209 267 358  52.3044E-18 M=1.0
C2210 267 271  25.6374E-18 M=1.0
C2211 266 316  25.6374E-18 M=1.0
C2212 266 272  25.6374E-18 M=1.0
C2213 266 271  51.2748E-18 M=1.0
C2214 266 269  26.5851E-18 M=1.0
C2215 266 267  88.2072E-18 M=1.0
C2216 261 265  25.6374E-18 M=1.0
C2217 260 273  51.2748E-18 M=1.0
C2218 260 265  51.2748E-18 M=1.0
C2219 260 264  52.3044E-18 M=1.0
C2220 260 263  69.741E-18 M=1.0
C2221 260 261  88.2072E-18 M=1.0
C2222 255 411  699.4602E-18 M=1.0
C2223 255 346  52.3044E-18 M=1.0
C2224 255 259  25.6374E-18 M=1.0
C2225 254 259  51.2748E-18 M=1.0
C2226 254 258  52.3044E-18 M=1.0
C2227 254 257  69.741E-18 M=1.0
C2228 254 255  88.2072E-18 M=1.0
C2229 252 329  52.3044E-18 M=1.0
C2230 249 253  25.6374E-18 M=1.0
C2231 248 329  146.0682E-18 M=1.0
C2232 248 324  121.5837E-18 M=1.0
C2233 248 253  103.5792E-18 M=1.0
C2234 248 252  96.553575E-18 M=1.0
C2235 248 251  70.6887E-18 M=1.0
C2236 248 249  88.68105E-18 M=1.0
C2237 247 322  148.2714E-18 M=1.0
C2238 247 272  62.5302E-18 M=1.0
C2239 247 270  52.3044E-18 M=1.0
C2240 247 266  25.6374E-18 M=1.0
C2241 245 324  41.7807E-18 M=1.0
C2242 245 278  44.1036E-18 M=1.0
C2243 244 278  88.2072E-18 M=1.0
C2244 243 247  44.1036E-18 M=1.0
C2245 242 324  223.2162E-18 M=1.0
C2246 241 278  52.3044E-18 M=1.0
C2247 236 240  77.9418E-18 M=1.0
C2248 235 832  203.13765E-18 M=1.0
C2249 235 285  43.20225E-18 M=1.0
C2250 235 240  77.9418E-18 M=1.0
C2251 235 238  77.9418E-18 M=1.0
C2252 235 236  88.68105E-18 M=1.0
C2253 234 324  26.4798E-18 M=1.0
C2254 234 278  462.87E-18 M=1.0
C2255 234 245  47.6892E-18 M=1.0
C2256 233 278  77.9418E-18 M=1.0
C2257 228 829  52.3044E-18 M=1.0
C2258 228 232  70.1631E-18 M=1.0
C2259 222 226  52.3044E-18 M=1.0
C2260 221 825  52.3044E-18 M=1.0
C2261 221 273  52.3044E-18 M=1.0
C2262 221 260  76.9122E-18 M=1.0
C2263 219 221  52.3044E-18 M=1.0
C2264 216 823  52.6203E-18 M=1.0
C2265 216 254  51.2748E-18 M=1.0
C2266 215 825  70.1847E-18 M=1.0
C2267 215 273  52.3044E-18 M=1.0
C2268 215 260  95.0625E-18 M=1.0
C2269 215 221  52.3044E-18 M=1.0
C2270 215 220  51.2748E-18 M=1.0
C2271 215 219  93.049425E-18 M=1.0
C2272 215 218  72.11025E-18 M=1.0
C2273 215 217  220.94325E-18 M=1.0
C2274 215 216  89.391825E-18 M=1.0
C2275 210 821  52.6203E-18 M=1.0
C2276 210 324  52.3044E-18 M=1.0
C2277 210 248  185.4036E-18 M=1.0
C2278 210 214  122.0454E-18 M=1.0
C2279 210 213  52.3044E-18 M=1.0
C2280 210 212  69.741E-18 M=1.0
C2281 209 823  105.145425E-18 M=1.0
C2282 209 254  95.0625E-18 M=1.0
C2283 209 216  77.9418E-18 M=1.0
C2284 208 209  52.3044E-18 M=1.0
C2285 204 411  52.3044E-18 M=1.0
C2286 204 346  52.3044E-18 M=1.0
C2287 204 342  739.007100000001E-18 M=1.0
C2288 204 259  25.6374E-18 M=1.0
C2289 204 255  351.789975E-18 M=1.0
C2290 204 254  30.22515E-18 M=1.0
C2291 204 208  52.3044E-18 M=1.0
C2292 203 823  52.3044E-18 M=1.0
C2293 203 254  76.9122E-18 M=1.0
C2294 203 216  52.3044E-18 M=1.0
C2295 203 209  103.5792E-18 M=1.0
C2296 203 208  302.364E-18 M=1.0
C2297 203 207  52.3044E-18 M=1.0
C2298 203 206  69.741E-18 M=1.0
C2299 200 324  51.2748E-18 M=1.0
C2300 200 279  1.0730646E-15 M=1.0
C2301 200 278  264.929175E-18 M=1.0
C2302 199 278  77.9418E-18 M=1.0
C2303 199 244  77.9418E-18 M=1.0
C2304 191 215  33.2703E-18 M=1.0
C2305 190 829  70.614E-18 M=1.0
C2306 190 228  52.3044E-18 M=1.0
C2307 185 829  87.5142E-18 M=1.0
C2308 185 228  52.3044E-18 M=1.0
C2309 185 190  52.3044E-18 M=1.0
C2310 180 210  120.6999E-18 M=1.0
C2311 179 221  100.8315E-18 M=1.0
C2312 176 179  72.5841E-18 M=1.0
C2313 174 209  131.9463E-18 M=1.0
C2314 174 203  118.9908E-18 M=1.0
C2315 173 178  103.5792E-18 M=1.0
C2316 173 176  69.741E-18 M=1.0
C2317 171 202  122.0454E-18 M=1.0
C2318 169 228  71.4348E-18 M=1.0
C2319 167 179  154.2843E-18 M=1.0
C2320 167 173  116.5779E-18 M=1.0
C2321 166 278  77.9418E-18 M=1.0
C2322 165 833  52.3044E-18 M=1.0
C2323 165 283  25.6374E-18 M=1.0
C2324 165 282  77.9418E-18 M=1.0
C2325 165 240  52.3044E-18 M=1.0
C2326 165 239  46.269E-18 M=1.0
C2327 165 235  162.6327E-18 M=1.0
C2328 147 228  71.4348E-18 M=1.0
C2329 145 179  118.845E-18 M=1.0
C2330 145 173  51.2748E-18 M=1.0
C2331 144 278  25.6374E-18 M=1.0
C2332 143 833  52.6203000000001E-18 M=1.0
C2333 143 283  25.6374E-18 M=1.0
C2334 143 282  181.701E-18 M=1.0
C2335 143 240  271.8522E-18 M=1.0
C2336 143 239  52.3044000000001E-18 M=1.0
C2337 143 235  95.9463E-18 M=1.0
C2338 143 165  52.3044E-18 M=1.0
C2339 142 164  52.3044E-18 M=1.0
C2340 141 164  65.7449999999999E-18 M=1.0
C2341 138 819  52.6203E-18 M=1.0
C2342 137 228  53.5761E-18 M=1.0
C2343 135 179  111.2121E-18 M=1.0
C2344 135 173  103.5792E-18 M=1.0
C2345 134 805  52.6203E-18 M=1.0
C2346 134 403  52.3044E-18 M=1.0
C2347 134 166  52.3044E-18 M=1.0
C2348 134 144  52.3044E-18 M=1.0
C2349 133 833  52.6203E-18 M=1.0
C2350 133 283  463.4541E-18 M=1.0
C2351 133 282  103.5792E-18 M=1.0
C2352 133 240  304.7454E-18 M=1.0
C2353 133 238  52.3044E-18 M=1.0
C2354 133 235  111.3579E-18 M=1.0
C2355 133 165  52.3044E-18 M=1.0
C2356 133 143  52.3044E-18 M=1.0
C2357 116 277  96.408E-18 M=1.0
C2358 116 276  52.3044E-18 M=1.0
C2359 116 228  51.2748E-18 M=1.0
C2360 116 190  25.6374E-18 M=1.0
C2361 116 185  95.09895E-18 M=1.0
C2362 113 806  52.6203E-18 M=1.0
C2363 113 338  52.3044E-18 M=1.0
C2364 113 278  58.9077E-18 M=1.0
C2365 113 245  307.7406E-18 M=1.0
C2366 113 199  96.408E-18 M=1.0
C2367 113 196  69.156E-18 M=1.0
C2368 113 134  72.3096E-18 M=1.0
C2369 112 818  52.6203E-18 M=1.0
C2370 112 165  343.23795E-18 M=1.0
C2371 112 143  70.3089E-18 M=1.0
C2372 112 133  52.3044E-18 M=1.0
C2373 102 203  193.8933E-18 M=1.0
C2374 101 403  52.3044E-18 M=1.0
C2375 101 244  97.8295499999999E-18 M=1.0
C2376 101 233  72.5840999999999E-18 M=1.0
C2377 101 199  51.2748E-18 M=1.0
C2378 101 166  25.6374E-18 M=1.0
C2379 101 144  95.044275E-18 M=1.0
C2380 101 134  209.9376E-18 M=1.0
C2381 38 324  25.6374E-18 M=1.0
C2382 38 278  84.5451E-18 M=1.0
C2383 38 245  25.6374E-18 M=1.0
C2384 38 113  52.3044E-18 M=1.0
C2385 37 235  46.2690000000002E-18 M=1.0
C2386 37 165  113.6592E-18 M=1.0
C2387 37 143  300.6396E-18 M=1.0
C2388 37 133  52.3044E-18 M=1.0
C2389 37 112  52.3044E-18 M=1.0
C2390 29 316  56.007E-18 M=1.0
C2391 29 272  248.2848E-18 M=1.0
C2392 29 271  52.3044E-18 M=1.0
C2393 29 247  52.3044E-18 M=1.0
C2394 29 226  52.3044E-18 M=1.0
C2395 29 187  296.153775E-18 M=1.0
C2396 28 825  52.3044E-18 M=1.0
C2397 28 273  327.6306E-18 M=1.0
C2398 28 264  52.3044E-18 M=1.0
C2399 28 219  52.3044E-18 M=1.0
C2400 27 276  52.3044E-18 M=1.0
C2401 27 228  51.2748E-18 M=1.0
C2402 27 190  59.0535E-18 M=1.0
C2403 7 278  58.9077E-18 M=1.0
C2404 7 245  25.6374E-18 M=1.0
C2405 7 113  52.3044E-18 M=1.0
C2406 6 818  52.3044E-18 M=1.0
C2407 6 165  72.756E-18 M=1.0
C2408 6 143  158.0301E-18 M=1.0
C2409 6 133  52.3044E-18 M=1.0
C2410 6 112  52.3044E-18 M=1.0
C2411 GD 695  409.9923E-18 M=1.0
C2412 GD 694  2.030597775E-15 M=1.0
C2413 GD 570  1.2086793E-15 M=1.0
C2414 GD 467  565.771275E-18 M=1.0
C2415 GD 278  1.812127725E-15 M=1.0
C2416 GD 273  120.260925E-18 M=1.0
C2417 GD 272  199.72935E-18 M=1.0
C2418 GD 261  930.60585E-18 M=1.0
C2419 GD 260  963.3231E-18 M=1.0
C2420 GD 254  1.01325015E-15 M=1.0
C2421 GD 248  577.764225E-18 M=1.0
C2422 GD 245  822.7701E-18 M=1.0
C2423 GD 236  2.11742505E-15 M=1.0
C2424 GD 235  1.03442085E-15 M=1.0
C2425 GD 228  1.20018915E-15 M=1.0
C2426 GD 221  370.72125E-18 M=1.0
C2427 GD 215  559.624725E-18 M=1.0
C2428 GD 210  1.005237E-15 M=1.0
C2429 GD 209  444.789E-18 M=1.0
C2430 GD 179  1.73113875E-15 M=1.0
C2431 GD 173  1.91564145E-15 M=1.0
C2432 GD 165  8.459765325E-15 M=1.0
C2433 GD 143  2.87887545E-15 M=1.0
C2434 GD 138  4.771053E-15 M=1.0
C2435 GD 134  7.8385437E-15 M=1.0
C2436 GD 133  9.017502975E-15 M=1.0
C2437 GD 113  4.08592845E-15 M=1.0
C2438 GD 112  3.22996815E-15 M=1.0
C2439 A0ININ 104  2.2316544E-15 M=1.0
C2440 A6B4 819  52.3044E-18 M=1.0
C2441 A6B4 171  102.5496E-18 M=1.0
C2442 A6B4 138  104.6088E-18 M=1.0
C2443 S_7 722  44.1036E-18 M=1.0
C2444 S_7 694  44.1036E-18 M=1.0
C2445 VD 695  175.29885E-18 M=1.0
C2446 VD 694  712.6848E-18 M=1.0
C2447 VD 324  1.6888104E-15 M=1.0
C2448 VD 278  963.157725000001E-18 M=1.0
C2449 VD 273  2.400108975E-15 M=1.0
C2450 VD 272  170.59995E-18 M=1.0
C2451 VD 267  296.9703E-18 M=1.0
C2452 VD 249  40.88565E-18 M=1.0
C2453 VD 248  532.1844E-18 M=1.0
C2454 VD 235  904.632075E-18 M=1.0
C2455 VD 228  123.8805E-18 M=1.0
C2456 VD 221  164.0043E-18 M=1.0
C2457 VD 215  140.443875E-18 M=1.0
C2458 VD 210  140.2596E-18 M=1.0
C2459 VD 209  298.221975E-18 M=1.0
C2460 VD 204  789.64245E-18 M=1.0
C2461 VD 203  775.522575E-18 M=1.0
C2462 VD 185  48.48975E-18 M=1.0
C2463 VD 164  299.7117E-18 M=1.0
C2464 VD 143  417.4803E-18 M=1.0
C2465 VD 142  160.416225E-18 M=1.0
C2466 VD 138  302.508E-18 M=1.0
C2467 VD 134  683.43885E-18 M=1.0
C2468 VD 133  631.290375E-18 M=1.0
C2469 VD 113  377.8434E-18 M=1.0
C2470 VD 29  675.654975E-18 M=1.0
C2471 VD 6  252.355275E-18 M=1.0
C2472 VD A6B4  241.279875E-18 M=1.0
C2473 CLK 542  707.4909E-18 M=1.0
C2474 A7B4 138  52.3044E-18 M=1.0
C2475 A7B3 819  52.6203E-18 M=1.0
C2476 A7B3 138  104.6088E-18 M=1.0
C2477 A7B3 A6B4  104.6088E-18 M=1.0
C2478 A7B3 VD  467.1018E-18 M=1.0
C2479 582 590  63.7317E-18 M=1.0
C2480 533 590  49.5477E-18 M=1.0
C2481 529 590  49.5477E-18 M=1.0
C2482 529 533  53.75565E-18 M=1.0
C2483 477 590  63.7317E-18 M=1.0
C2484 245 338  49.5477E-18 M=1.0
C2485 227 232  197.7363E-18 M=1.0
C2486 227 230  64.755E-18 M=1.0
C2487 227 228  83.3373E-18 M=1.0
C2488 222 423  49.5477E-18 M=1.0
C2489 222 419  49.5477E-18 M=1.0
C2490 222 415  20.5659E-18 M=1.0
C2491 222 358  49.5477E-18 M=1.0
C2492 222 354  49.5477E-18 M=1.0
C2493 222 350  49.5477E-18 M=1.0
C2494 222 346  1.28310075E-15 M=1.0
C2495 222 255  88.04385E-18 M=1.0
C2496 222 226  21.0402E-18 M=1.0
C2497 221 423  49.5477E-18 M=1.0
C2498 221 358  49.5477E-18 M=1.0
C2499 221 354  49.5477E-18 M=1.0
C2500 221 222  102.3534E-18 M=1.0
C2501 220 222  85.7952E-18 M=1.0
C2502 218 222  64.755E-18 M=1.0
C2503 216 222  102.3534E-18 M=1.0
C2504 215 222  74.1573E-18 M=1.0
C2505 209 411  49.5477E-18 M=1.0
C2506 209 346  49.5477E-18 M=1.0
C2507 209 342  49.5477E-18 M=1.0
C2508 209 279  63.1206E-18 M=1.0
C2509 209 278  84.1608E-18 M=1.0
C2510 209 222  58.6386E-18 M=1.0
C2511 209 214  85.7952E-18 M=1.0
C2512 209 212  132.669E-18 M=1.0
C2513 209 210  74.1573E-18 M=1.0
C2514 208 222  85.7952E-18 M=1.0
C2515 208 209  42.0804E-18 M=1.0
C2516 207 222  89.6265E-18 M=1.0
C2517 206 222  64.755E-18 M=1.0
C2518 206 209  135.963E-18 M=1.0
C2519 205 222  89.6265E-18 M=1.0
C2520 204 209  83.3373E-18 M=1.0
C2521 203 222  102.3534E-18 M=1.0
C2522 203 209  43.7148E-18 M=1.0
C2523 201 227  49.5477E-18 M=1.0
C2524 199 245  49.5477E-18 M=1.0
C2525 191 222  71.48565E-18 M=1.0
C2526 191 221  29.40525E-18 M=1.0
C2527 185 829  33.13305E-18 M=1.0
C2528 185 828  100.035E-18 M=1.0
C2529 185 431  49.5477E-18 M=1.0
C2530 185 427  869.804325E-18 M=1.0
C2531 185 362  49.5477E-18 M=1.0
C2532 185 277  42.0804E-18 M=1.0
C2533 185 275  59.8014E-18 M=1.0
C2534 185 273  136.512E-18 M=1.0
C2535 185 228  42.0804E-18 M=1.0
C2536 185 190  63.1206E-18 M=1.0
C2537 180 209  84.1608E-18 M=1.0
C2538 179 222  63.1206E-18 M=1.0
C2539 174 222  42.0804E-18 M=1.0
C2540 174 209  21.0402E-18 M=1.0
C2541 173 222  63.1206E-18 M=1.0
C2542 171 227  117.2772E-18 M=1.0
C2543 170 289  36.486E-18 M=1.0
C2544 170 247  43.7148E-18 M=1.0
C2545 170 243  43.7148E-18 M=1.0
C2546 170 171  150.8508E-18 M=1.0
C2547 169 227  84.1608E-18 M=1.0
C2548 166 245  49.5477E-18 M=1.0
C2549 147 227  84.1608E-18 M=1.0
C2550 144 245  49.5477E-18 M=1.0
C2551 138 170  61.77195E-18 M=1.0
C2552 137 227  63.1206E-18 M=1.0
C2553 134 245  65.853E-18 M=1.0
C2554 116 227  58.6386E-18 M=1.0
C2555 104 227  58.6386E-18 M=1.0
C2556 102 222  63.1206E-18 M=1.0
C2557 102 209  21.0402E-18 M=1.0
C2558 101 245  58.6386000000001E-18 M=1.0
C2559 40 818  344.2257E-18 M=1.0
C2560 40 817  201.8844E-18 M=1.0
C2561 40 806  49.5477E-18 M=1.0
C2562 40 805  49.5477E-18 M=1.0
C2563 40 423  49.5477E-18 M=1.0
C2564 40 419  49.5477E-18 M=1.0
C2565 40 415  20.5659E-18 M=1.0
C2566 40 411  49.5477E-18 M=1.0
C2567 40 407  49.5477E-18 M=1.0
C2568 40 403  49.5477E-18 M=1.0
C2569 40 358  49.5477E-18 M=1.0
C2570 40 354  49.5477E-18 M=1.0
C2571 40 350  49.5477E-18 M=1.0
C2572 40 346  49.5477E-18 M=1.0
C2573 40 342  49.5477E-18 M=1.0
C2574 40 338  49.5477E-18 M=1.0
C2575 40 279  159.3576E-18 M=1.0
C2576 40 278  142.7994E-18 M=1.0
C2577 40 240  29.40525E-18 M=1.0
C2578 40 238  66.5775E-18 M=1.0
C2579 40 236  44.8083E-18 M=1.0
C2580 40 226  85.7952E-18 M=1.0
C2581 40 224  64.755E-18 M=1.0
C2582 40 222  84.7629E-18 M=1.0
C2583 40 221  84.7629E-18 M=1.0
C2584 40 220  85.7952E-18 M=1.0
C2585 40 218  64.755E-18 M=1.0
C2586 40 216  144.58275E-18 M=1.0
C2587 40 215  84.7629E-18 M=1.0
C2588 40 214  85.7952E-18 M=1.0
C2589 40 212  64.755E-18 M=1.0
C2590 40 210  84.7629E-18 M=1.0
C2591 40 209  89.64945E-18 M=1.0
C2592 40 208  85.7952E-18 M=1.0
C2593 40 206  64.755E-18 M=1.0
C2594 40 204  86.9256E-18 M=1.0
C2595 40 203  143.2917E-18 M=1.0
C2596 40 200  269.48295E-18 M=1.0
C2597 40 199  292.105125E-18 M=1.0
C2598 40 198  49.5477E-18 M=1.0
C2599 40 196  49.5477E-18 M=1.0
C2600 40 187  109.08405E-18 M=1.0
C2601 40 180  84.1608E-18 M=1.0
C2602 40 179  84.1608E-18 M=1.0
C2603 40 174  196.8075E-18 M=1.0
C2604 40 173  100.719E-18 M=1.0
C2605 40 166  49.5477E-18 M=1.0
C2606 40 165  58.6386E-18 M=1.0
C2607 40 144  49.5477E-18 M=1.0
C2608 40 143  58.6386000000001E-18 M=1.0
C2609 40 142  49.5477E-18 M=1.0
C2610 40 134  58.6386000000001E-18 M=1.0
C2611 40 133  58.6386E-18 M=1.0
C2612 40 113  58.6386000000001E-18 M=1.0
C2613 40 112  67.00365E-18 M=1.0
C2614 40 102  84.1608E-18 M=1.0
C2615 40 101  20.5659E-18 M=1.0
C2616 38 245  49.5477E-18 M=1.0
C2617 38 40  99.0954000000001E-18 M=1.0
C2618 37 240  21.0402E-18 M=1.0
C2619 37 238  21.0402E-18 M=1.0
C2620 37 236  43.7148E-18 M=1.0
C2621 37 235  132.7959E-18 M=1.0
C2622 37 165  58.6386E-18 M=1.0
C2623 37 143  58.6386000000001E-18 M=1.0
C2624 37 142  49.5477E-18 M=1.0
C2625 37 133  58.6386E-18 M=1.0
C2626 37 112  58.6386000000001E-18 M=1.0
C2627 37 40  42.0804E-18 M=1.0
C2628 29 316  24.77385E-18 M=1.0
C2629 29 273  58.6386E-18 M=1.0
C2630 29 272  60.143175E-18 M=1.0
C2631 29 187  26.342775E-18 M=1.0
C2632 29 40  58.6386E-18 M=1.0
C2633 28 222  58.6386E-18 M=1.0
C2634 28 221  58.6386E-18 M=1.0
C2635 28 40  58.6386E-18 M=1.0
C2636 27 227  58.6386E-18 M=1.0
C2637 26 40  84.1608E-18 M=1.0
C2638 25 222  84.1608E-18 M=1.0
C2639 25 209  21.0402E-18 M=1.0
C2640 25 40  84.1608E-18 M=1.0
C2641 7 245  49.5477E-18 M=1.0
C2642 GD 590  237.7278E-18 M=1.0
C2643 GD 245  363.1959E-18 M=1.0
C2644 GD 227  2.8839123E-15 M=1.0
C2645 GD 222  2.6928711E-15 M=1.0
C2646 GD 221  261.3168E-18 M=1.0
C2647 GD 209  1.3221216E-15 M=1.0
C2648 GD 40  4.6143963E-15 M=1.0
C2649 GD 37  965.2401E-18 M=1.0
C2650 GD 29  2.83710105E-15 M=1.0
C2651 A0ININ 227  24.77385E-18 M=1.0
C2652 A6B4 227  188.5473E-18 M=1.0
C2653 A6B4 170  71.172E-18 M=1.0
C2654 VD 245  199.3509E-18 M=1.0
C2655 VD 190  1.2955374E-15 M=1.0
C2656 VD 185  508.9086E-18 M=1.0
C2657 VD 170  1.0513368E-15 M=1.0
C2658 VD 40  630.63225E-18 M=1.0
C2659 VD 29  77.09805E-18 M=1.0
C2660 A7B3 170  541.20645E-18 M=1.0
C2661 GD 423  238.8528E-18 M=1.0
C2662 GD 419  238.8528E-18 M=1.0
C2663 GD 346  188.568E-18 M=1.0
C2664 GD 163  31.8208500000004E-18 M=1.0
C2665 GD 162  31.8208500000001E-18 M=1.0
C2666 GD 161  31.8208499999999E-18 M=1.0
C2667 GD 160  31.82085E-18 M=1.0
C2668 GD 159  31.82085E-18 M=1.0
C2669 GD 158  31.82085E-18 M=1.0
C2670 GD 157  31.82085E-18 M=1.0
C2671 GD 156  31.8208499999999E-18 M=1.0
C2672 GD 129  31.82085E-18 M=1.0
C2673 GD 115  248.2812E-18 M=1.0
C2674 VD 431  113.1408E-18 M=1.0
C2675 VD 419  113.1408E-18 M=1.0
C2676 VD 338  295.423200000001E-18 M=1.0
C2677 VD 187  40.0706999999999E-18 M=1.0
C2678 VD 163  32.6065499999999E-18 M=1.0
C2679 VD 162  32.6065499999999E-18 M=1.0
C2680 VD 161  32.6065500000003E-18 M=1.0
C2681 VD 160  32.6065500000001E-18 M=1.0
C2682 VD 159  32.6065499999999E-18 M=1.0
C2683 VD 158  32.60655E-18 M=1.0
C2684 VD 157  32.6065499999999E-18 M=1.0
C2685 VD 156  32.6065500000001E-18 M=1.0
C2686 VD 130  32.6065500000003E-18 M=1.0
C2687 VD 40  74.6415E-18 M=1.0
C2688 VD 26  53.4276000000001E-18 M=1.0
C2689 362 419  75.2328E-18 M=1.0
C2690 358 419  75.2328E-18 M=1.0
C2691 354 419  75.2328E-18 M=1.0
C2692 350 419  75.2328E-18 M=1.0
C2693 346 419  75.2328E-18 M=1.0
C2694 342 419  75.2328E-18 M=1.0
C2695 338 419  75.2328E-18 M=1.0
C2696 163 419  75.2328E-18 M=1.0
C2697 162 419  75.2328E-18 M=1.0
C2698 161 419  75.2328E-18 M=1.0
C2699 160 419  75.2328E-18 M=1.0
C2700 159 419  75.2328E-18 M=1.0
C2701 158 419  75.2328E-18 M=1.0
C2702 157 419  75.2328E-18 M=1.0
C2703 156 419  75.2328E-18 M=1.0
C2704 40 187  454.8447E-18 M=1.0
C2705 GD 419  3.73691879999999E-15 M=1.0
C2706 GD 358  316.703699999999E-18 M=1.0
C2707 GD 350  316.7037E-18 M=1.0
C2708 GD 166  133.0416E-18 M=1.0
C2709 GD 165  133.0416E-18 M=1.0
C2710 GD 164  136.2294E-18 M=1.0
C2711 GD 163  78.5412E-18 M=1.0
C2712 GD 162  78.5412E-18 M=1.0
C2713 GD 161  78.5412E-18 M=1.0
C2714 GD 160  78.5412E-18 M=1.0
C2715 GD 159  78.5412E-18 M=1.0
C2716 GD 158  78.5412E-18 M=1.0
C2717 GD 157  78.5412E-18 M=1.0
C2718 GD 156  78.5412E-18 M=1.0
C2719 A0ININ 419  75.2328E-18 M=1.0
C2720 VD 338  193.7304E-18 M=1.0
C2721 VD 224  30.4272E-18 M=1.0
C2722 VD 187  30.4272E-18 M=1.0
C2723 VD 169  34.2306E-18 M=1.0
C2724 VD 168  34.2306E-18 M=1.0
C2725 VD 167  34.2306E-18 M=1.0
C2726 VD 166  34.2306E-18 M=1.0
C2727 VD 165  34.2306E-18 M=1.0
C2728 VD 164  34.2306E-18 M=1.0
C2729 VD 163  56.0232E-18 M=1.0
C2730 VD 162  56.0232E-18 M=1.0
C2731 VD 161  56.0232E-18 M=1.0
C2732 VD 160  56.0232E-18 M=1.0
C2733 VD 159  56.0232E-18 M=1.0
C2734 VD 158  56.0232E-18 M=1.0
C2735 VD 157  56.0232E-18 M=1.0
C2736 VD 156  56.0232E-18 M=1.0
C2737 VD 40  109.8144E-18 M=1.0
C2738 VD A6B4  34.2306E-18 M=1.0
C2739 A7B4 GD  60.6456E-18 M=1.0
C2740 346 431  34.9776E-18 M=1.0
C2741 346 427  34.9776E-18 M=1.0
C2742 346 423  34.9776E-18 M=1.0
C2743 187 799  68.7384E-18 M=1.0
C2744 169 419  1.8841248E-15 M=1.0
C2745 138 346  65.5065E-18 M=1.0
C2746 130 346  100.9458E-18 M=1.0
C2747 115 799  34.9776E-18 M=1.0
C2748 115 187  127.7451E-18 M=1.0
C2749 106 346  65.5065E-18 M=1.0
C2750 103 187  139.9104E-18 M=1.0
C2751 98 346  100.9458E-18 M=1.0
C2752 40 799  34.9776E-18 M=1.0
C2753 40 187  65.0448E-18 M=1.0
C2754 40 115  104.9328E-18 M=1.0
C2755 30 346  65.5065E-18 M=1.0
C2756 28 419  34.9776E-18 M=1.0
C2757 28 166  55.2771E-18 M=1.0
C2758 28 158  90.8703E-18 M=1.0
C2759 26 226  204.9552E-18 M=1.0
C2760 22 346  100.9458E-18 M=1.0
C2761 GD 133  3.0400875E-15 M=1.0
C2762 A6B4 GD  5.2574733E-15 M=1.0
C2763 VD 346  3.74032035E-15 M=1.0
C2764 A7B4 GD  12.4435998E-15 M=1.0
C2765 342 346  104.6088E-18 M=1.0
C2766 168 431  37.6677E-18 M=1.0
C2767 168 427  37.6677E-18 M=1.0
C2768 168 423  37.6677E-18 M=1.0
C2769 168 419  22.0518E-18 M=1.0
C2770 168 169  199.6713E-18 M=1.0
C2771 167 419  645.86565E-18 M=1.0
C2772 159 167  251.3835E-18 M=1.0
C2773 158 167  119.7549E-18 M=1.0
C2774 157 167  119.7549E-18 M=1.0
C2775 156 167  119.7549E-18 M=1.0
C2776 137 346  52.3044E-18 M=1.0
C2777 137 169  104.6088E-18 M=1.0
C2778 136 346  52.3044E-18 M=1.0
C2779 136 168  104.6088E-18 M=1.0
C2780 134 431  37.6677E-18 M=1.0
C2781 134 427  37.6677E-18 M=1.0
C2782 134 423  37.6677E-18 M=1.0
C2783 134 358  52.3044E-18 M=1.0
C2784 134 354  52.3044E-18 M=1.0
C2785 134 350  52.3044E-18 M=1.0
C2786 134 346  52.3044E-18 M=1.0
C2787 134 342  52.3044E-18 M=1.0
C2788 134 338  52.3044E-18 M=1.0
C2789 134 137  52.3044E-18 M=1.0
C2790 134 136  52.3044E-18 M=1.0
C2791 133 431  37.6677E-18 M=1.0
C2792 133 427  37.6677E-18 M=1.0
C2793 133 423  37.6677E-18 M=1.0
C2794 133 362  52.3044E-18 M=1.0
C2795 133 358  52.3044E-18 M=1.0
C2796 133 354  52.3044E-18 M=1.0
C2797 133 350  52.3044E-18 M=1.0
C2798 133 346  52.3044E-18 M=1.0
C2799 133 342  52.3044E-18 M=1.0
C2800 133 338  52.3044E-18 M=1.0
C2801 133 137  52.3044E-18 M=1.0
C2802 133 136  52.3044E-18 M=1.0
C2803 105 346  52.3044E-18 M=1.0
C2804 104 346  52.3044E-18 M=1.0
C2805 104 134  52.3044E-18 M=1.0
C2806 104 133  52.3044E-18 M=1.0
C2807 103 346  52.3044E-18 M=1.0
C2808 103 187  69.156E-18 M=1.0
C2809 101 346  52.3044E-18 M=1.0
C2810 40 187  43.9335E-18 M=1.0
C2811 29 799  52.3044E-18 M=1.0
C2812 29 423  37.6677E-18 M=1.0
C2813 29 419  37.6677E-18 M=1.0
C2814 29 362  52.3044E-18 M=1.0
C2815 29 346  52.3044E-18 M=1.0
C2816 29 115  270.222525E-18 M=1.0
C2817 29 40  52.3044E-18 M=1.0
C2818 28 167  52.3044E-18 M=1.0
C2819 28 134  52.3044E-18 M=1.0
C2820 28 133  52.3044E-18 M=1.0
C2821 27 346  52.3044E-18 M=1.0
C2822 27 134  52.3044E-18 M=1.0
C2823 27 133  52.3044E-18 M=1.0
C2824 26 346  52.3044E-18 M=1.0
C2825 26 187  52.3044E-18 M=1.0
C2826 26 169  52.3044E-18 M=1.0
C2827 26 168  52.3044E-18 M=1.0
C2828 26 134  52.3044E-18 M=1.0
C2829 26 133  52.3044E-18 M=1.0
C2830 26 29  52.3044E-18 M=1.0
C2831 25 167  52.3044E-18 M=1.0
C2832 GD 187  255.82005E-18 M=1.0
C2833 GD 167  3.8674494E-15 M=1.0
C2834 GD 101  6.7634424E-15 M=1.0
C2835 A0ININ 29  52.3044E-18 M=1.0
C2836 A6B4 431  37.6677E-18 M=1.0
C2837 A6B4 427  37.6677E-18 M=1.0
C2838 A6B4 423  37.6677E-18 M=1.0
C2839 A6B4 419  37.6677E-18 M=1.0
C2840 A6B4 137  52.3044E-18 M=1.0
C2841 A6B4 136  52.3044E-18 M=1.0
C2842 A6B4 134  52.3044E-18 M=1.0
C2843 A6B4 133  52.3044E-18 M=1.0
C2844 A6B4 104  52.3044E-18 M=1.0
C2845 A6B4 103  52.3044E-18 M=1.0
C2846 A6B4 101  52.3044E-18 M=1.0
C2847 A6B4 29  52.3044E-18 M=1.0
C2848 A6B4 27  52.3044E-18 M=1.0
C2849 A6B4 26  52.3044E-18 M=1.0
C2850 A6B4 GD  3.682426275E-15 M=1.0
C2851 VD 187  162.6723E-18 M=1.0
C2852 VD 167  642.050325E-18 M=1.0
C2853 VD 165  593.622675E-18 M=1.0
C2854 A7B4 431  37.6677E-18 M=1.0
C2855 A7B4 427  37.6677E-18 M=1.0
C2856 A7B4 423  37.6677E-18 M=1.0
C2857 A7B4 419  37.6677E-18 M=1.0
C2858 A7B4 137  52.3044E-18 M=1.0
C2859 A7B4 136  52.3044E-18 M=1.0
C2860 A7B4 134  52.3044E-18 M=1.0
C2861 A7B4 133  52.3044E-18 M=1.0
C2862 A7B4 104  52.3044E-18 M=1.0
C2863 A7B4 103  52.3044E-18 M=1.0
C2864 A7B4 101  52.3044E-18 M=1.0
C2865 A7B4 29  52.3044E-18 M=1.0
C2866 A7B4 27  52.3044E-18 M=1.0
C2867 A7B4 26  52.3044E-18 M=1.0
C2868 A7B4 GD  3.1949757E-15 M=1.0
C2869 362 419  133.7067E-18 M=1.0
C2870 358 419  125.2908E-18 M=1.0
C2871 354 419  129.49875E-18 M=1.0
C2872 350 419  125.2908E-18 M=1.0
C2873 346 431  129.49875E-18 M=1.0
C2874 346 427  129.49875E-18 M=1.0
C2875 346 423  129.49875E-18 M=1.0
C2876 346 419  129.49875E-18 M=1.0
C2877 342 419  129.49875E-18 M=1.0
C2878 338 419  125.2908E-18 M=1.0
C2879 187 191  44.6058E-18 M=1.0
C2880 185 187  87.7131E-18 M=1.0
C2881 137 419  49.5477E-18 M=1.0
C2882 40 191  270.13455E-18 M=1.0
C2883 29 191  58.6386E-18 M=1.0
C2884 29 185  58.6386E-18 M=1.0
C2885 29 147  58.6386E-18 M=1.0
C2886 29 146  58.6386E-18 M=1.0
C2887 29 116  58.6386E-18 M=1.0
C2888 29 115  58.6386E-18 M=1.0
C2889 28 419  49.5477E-18 M=1.0
C2890 26 419  49.5477E-18 M=1.0
C2891 25 419  49.5477E-18 M=1.0
C2892 GD 419  1.8665487E-15 M=1.0
C2893 A0ININ 419  142.1226E-18 M=1.0
C2894 VD 419  1.0404432E-15 M=1.0
C2895 A7B3 29  58.6386E-18 M=1.0
C2896 GD 431  238.8528E-18 M=1.0
C2897 GD 338  188.568E-18 M=1.0
C2898 GD 132  31.8208500000004E-18 M=1.0
C2899 GD 131  31.8208500000001E-18 M=1.0
C2900 GD 130  31.8208499999999E-18 M=1.0
C2901 GD 100  31.8208500000004E-18 M=1.0
C2902 GD 99  31.8208500000001E-18 M=1.0
C2903 GD 98  31.8208499999999E-18 M=1.0
C2904 GD 24  31.8208500000004E-18 M=1.0
C2905 GD 23  31.8208500000001E-18 M=1.0
C2906 GD 22  31.8208499999999E-18 M=1.0
C2907 VD 423  113.1408E-18 M=1.0
C2908 VD 346  295.423200000001E-18 M=1.0
C2909 VD 132  32.6065499999999E-18 M=1.0
C2910 VD 131  32.6065499999999E-18 M=1.0
C2911 VD 100  32.6065499999999E-18 M=1.0
C2912 VD 99  32.6065499999999E-18 M=1.0
C2913 VD 98  32.6065500000003E-18 M=1.0
C2914 VD 24  32.6065499999999E-18 M=1.0
C2915 VD 23  32.6065499999999E-18 M=1.0
C2916 VD 22  32.6065500000003E-18 M=1.0
C2917 346 431  75.2328E-18 M=1.0
C2918 346 427  75.2328E-18 M=1.0
C2919 346 423  75.2328E-18 M=1.0
C2920 342 431  75.2328E-18 M=1.0
C2921 342 427  75.2328E-18 M=1.0
C2922 342 423  75.2328E-18 M=1.0
C2923 338 431  75.2328E-18 M=1.0
C2924 338 427  75.2328E-18 M=1.0
C2925 338 423  75.2328E-18 M=1.0
C2926 132 423  75.2328E-18 M=1.0
C2927 131 423  75.2328E-18 M=1.0
C2928 130 423  75.2328E-18 M=1.0
C2929 100 427  75.2328E-18 M=1.0
C2930 99 427  75.2328E-18 M=1.0
C2931 98 427  75.2328E-18 M=1.0
C2932 24 431  75.2328E-18 M=1.0
C2933 23 431  75.2328E-18 M=1.0
C2934 22 431  75.2328E-18 M=1.0
C2935 GD 431  4.0297806E-15 M=1.0
C2936 GD 423  3.9594177E-15 M=1.0
C2937 GD 346  316.7037E-18 M=1.0
C2938 GD 140  60.6456E-18 M=1.0
C2939 GD 139  136.2294E-18 M=1.0
C2940 GD 132  78.5412E-18 M=1.0
C2941 GD 131  78.5412E-18 M=1.0
C2942 GD 130  78.5412E-18 M=1.0
C2943 GD 108  60.6456E-18 M=1.0
C2944 GD 100  78.5412E-18 M=1.0
C2945 GD 99  78.5412E-18 M=1.0
C2946 GD 98  78.5412E-18 M=1.0
C2947 GD 32  60.6456E-18 M=1.0
C2948 GD 24  78.5412E-18 M=1.0
C2949 GD 23  78.5412E-18 M=1.0
C2950 GD 22  78.5412E-18 M=1.0
C2951 VD 346  193.7304E-18 M=1.0
C2952 VD 139  34.2306E-18 M=1.0
C2953 VD 138  34.2306E-18 M=1.0
C2954 VD 132  56.0232E-18 M=1.0
C2955 VD 131  56.0232E-18 M=1.0
C2956 VD 130  56.0232E-18 M=1.0
C2957 VD 107  34.2306E-18 M=1.0
C2958 VD 106  34.2306E-18 M=1.0
C2959 VD 100  56.0232E-18 M=1.0
C2960 VD 99  56.0232E-18 M=1.0
C2961 VD 98  56.0232E-18 M=1.0
C2962 VD 31  34.2306E-18 M=1.0
C2963 VD 30  34.2306E-18 M=1.0
C2964 VD 24  56.0232E-18 M=1.0
C2965 VD 23  56.0232E-18 M=1.0
C2966 VD 22  56.0232E-18 M=1.0
C2967 342 431  34.9776E-18 M=1.0
C2968 342 427  34.9776E-18 M=1.0
C2969 342 423  34.9776E-18 M=1.0
C2970 338 431  34.9776E-18 M=1.0
C2971 338 427  34.9776E-18 M=1.0
C2972 338 423  34.9776E-18 M=1.0
C2973 140 338  65.5065E-18 M=1.0
C2974 139 342  65.5065E-18 M=1.0
C2975 132 338  100.9458E-18 M=1.0
C2976 131 342  100.9458E-18 M=1.0
C2977 108 338  65.5065E-18 M=1.0
C2978 107 342  65.5065E-18 M=1.0
C2979 100 338  100.9458E-18 M=1.0
C2980 99 342  100.9458E-18 M=1.0
C2981 32 338  65.5065E-18 M=1.0
C2982 31 342  65.5065E-18 M=1.0
C2983 24 338  100.9458E-18 M=1.0
C2984 23 342  100.9458E-18 M=1.0
C2985 GD 140  12.1988583E-15 M=1.0
C2986 GD 108  14.9018922E-15 M=1.0
C2987 GD 105  9.47950829999999E-15 M=1.0
C2988 GD 104  5.025213E-15 M=1.0
C2989 GD 103  4.9110003E-15 M=1.0
C2990 GD 32  16.8870177E-15 M=1.0
C2991 GD 29  6.2706753E-15 M=1.0
C2992 GD 26  7.0429131E-15 M=1.0
C2993 VD 342  4.8048174E-15 M=1.0
C2994 VD 338  3.6842544E-15 M=1.0
C2995 140 431  37.6677E-18 M=1.0
C2996 140 427  37.6677E-18 M=1.0
C2997 140 423  37.6677E-18 M=1.0
C2998 139 431  37.6677E-18 M=1.0
C2999 139 427  37.6677E-18 M=1.0
C3000 139 423  37.6677E-18 M=1.0
C3001 139 338  52.3044E-18 M=1.0
C3002 138 431  37.6677E-18 M=1.0
C3003 138 427  37.6677E-18 M=1.0
C3004 138 423  37.6677E-18 M=1.0
C3005 138 342  52.3044E-18 M=1.0
C3006 138 338  52.3044E-18 M=1.0
C3007 137 342  52.3044E-18 M=1.0
C3008 137 338  52.3044E-18 M=1.0
C3009 136 427  37.6677E-18 M=1.0
C3010 136 423  37.6677E-18 M=1.0
C3011 136 342  52.3044E-18 M=1.0
C3012 136 338  52.3044E-18 M=1.0
C3013 136 137  135.1404E-18 M=1.0
C3014 108 431  37.6677E-18 M=1.0
C3015 108 427  37.6677E-18 M=1.0
C3016 107 431  37.6677E-18 M=1.0
C3017 107 427  37.6677E-18 M=1.0
C3018 107 338  52.3044E-18 M=1.0
C3019 106 431  37.6677E-18 M=1.0
C3020 106 427  37.6677E-18 M=1.0
C3021 106 342  52.3044E-18 M=1.0
C3022 106 338  52.3044E-18 M=1.0
C3023 105 431  37.6677E-18 M=1.0
C3024 105 427  37.6677E-18 M=1.0
C3025 105 342  52.3044E-18 M=1.0
C3026 105 338  52.3044E-18 M=1.0
C3027 104 431  37.6677E-18 M=1.0
C3028 104 427  37.6677E-18 M=1.0
C3029 104 342  52.3044E-18 M=1.0
C3030 104 338  52.3044E-18 M=1.0
C3031 104 140  52.3044E-18 M=1.0
C3032 104 139  52.3044E-18 M=1.0
C3033 104 138  52.3044E-18 M=1.0
C3034 103 431  37.6677E-18 M=1.0
C3035 103 342  52.3044E-18 M=1.0
C3036 103 338  52.3044E-18 M=1.0
C3037 103 140  52.3044E-18 M=1.0
C3038 103 139  52.3044E-18 M=1.0
C3039 103 138  52.3044E-18 M=1.0
C3040 103 104  52.3044E-18 M=1.0
C3041 101 431  37.6677E-18 M=1.0
C3042 101 427  37.6677E-18 M=1.0
C3043 101 342  52.3044E-18 M=1.0
C3044 101 338  52.3044E-18 M=1.0
C3045 101 140  52.3044E-18 M=1.0
C3046 101 139  52.3044E-18 M=1.0
C3047 101 138  52.3044E-18 M=1.0
C3048 101 104  52.3044E-18 M=1.0
C3049 32 431  37.6677E-18 M=1.0
C3050 31 431  37.6677E-18 M=1.0
C3051 31 338  52.3044E-18 M=1.0
C3052 30 431  37.6677E-18 M=1.0
C3053 30 342  52.3044E-18 M=1.0
C3054 30 338  52.3044E-18 M=1.0
C3055 29 431  37.6677E-18 M=1.0
C3056 29 342  52.3044E-18 M=1.0
C3057 29 338  52.3044E-18 M=1.0
C3058 29 140  52.3044E-18 M=1.0
C3059 29 139  52.3044E-18 M=1.0
C3060 29 138  52.3044E-18 M=1.0
C3061 29 108  52.3044E-18 M=1.0
C3062 29 107  52.3044E-18 M=1.0
C3063 29 106  52.3044E-18 M=1.0
C3064 29 105  52.3044E-18 M=1.0
C3065 29 103  104.6088E-18 M=1.0
C3066 27 431  37.6677E-18 M=1.0
C3067 27 342  52.3044E-18 M=1.0
C3068 27 338  52.3044E-18 M=1.0
C3069 27 140  52.3044E-18 M=1.0
C3070 27 139  52.3044E-18 M=1.0
C3071 27 138  52.3044E-18 M=1.0
C3072 27 108  52.3044E-18 M=1.0
C3073 27 107  52.3044E-18 M=1.0
C3074 27 106  52.3044E-18 M=1.0
C3075 27 105  52.3044E-18 M=1.0
C3076 27 104  104.6088E-18 M=1.0
C3077 27 103  52.3044E-18 M=1.0
C3078 27 101  52.3044E-18 M=1.0
C3079 26 342  52.3044E-18 M=1.0
C3080 26 338  52.3044E-18 M=1.0
C3081 26 140  52.3044E-18 M=1.0
C3082 26 139  52.3044E-18 M=1.0
C3083 26 138  52.3044E-18 M=1.0
C3084 26 137  52.3044E-18 M=1.0
C3085 26 136  52.3044E-18 M=1.0
C3086 26 108  52.3044E-18 M=1.0
C3087 26 107  52.3044E-18 M=1.0
C3088 26 106  52.3044E-18 M=1.0
C3089 26 105  52.3044E-18 M=1.0
C3090 26 104  52.3044E-18 M=1.0
C3091 26 101  52.3044E-18 M=1.0
C3092 GD 139  4.534803675E-15 M=1.0
C3093 GD 136  3.5749773E-15 M=1.0
C3094 GD 106  5.8168314E-15 M=1.0
C3095 GD 104  5.333340375E-15 M=1.0
C3096 GD 103  5.84110935E-15 M=1.0
C3097 GD 32  7.7952951E-15 M=1.0
C3098 GD 29  5.8353408E-15 M=1.0
C3099 GD 27  7.120480275E-15 M=1.0
C3100 VD 139  302.386275E-18 M=1.0
C3101 VD 107  267.514875E-18 M=1.0
C3102 VD 106  300.798E-18 M=1.0
C3103 342 431  129.49875E-18 M=1.0
C3104 342 427  129.49875E-18 M=1.0
C3105 342 423  129.49875E-18 M=1.0
C3106 338 431  125.2908E-18 M=1.0
C3107 338 427  125.2908E-18 M=1.0
C3108 338 423  125.2908E-18 M=1.0
C3109 26 427  49.5477E-18 M=1.0
C3110 26 423  49.5477E-18 M=1.0
C3111 GD 427  2.0483343E-15 M=1.0
C3112 GD 427  238.8528E-18 M=1.0
C3113 GD 128  31.82085E-18 M=1.0
C3114 GD 127  31.82085E-18 M=1.0
C3115 GD 126  31.82085E-18 M=1.0
C3116 GD 125  31.8208499999999E-18 M=1.0
C3117 GD 97  31.82085E-18 M=1.0
C3118 GD 96  31.82085E-18 M=1.0
C3119 GD 95  31.82085E-18 M=1.0
C3120 GD 94  31.82085E-18 M=1.0
C3121 GD 93  31.8208499999999E-18 M=1.0
C3122 GD 21  31.82085E-18 M=1.0
C3123 GD 20  31.82085E-18 M=1.0
C3124 GD 19  31.82085E-18 M=1.0
C3125 GD 18  31.82085E-18 M=1.0
C3126 GD 17  31.8208499999999E-18 M=1.0
C3127 VD 427  113.1408E-18 M=1.0
C3128 VD 362  295.423200000001E-18 M=1.0
C3129 VD 358  295.423200000004E-18 M=1.0
C3130 VD 354  295.423200000001E-18 M=1.0
C3131 VD 129  32.6065500000001E-18 M=1.0
C3132 VD 128  32.6065499999999E-18 M=1.0
C3133 VD 127  32.60655E-18 M=1.0
C3134 VD 126  32.6065499999999E-18 M=1.0
C3135 VD 125  32.6065500000001E-18 M=1.0
C3136 VD 97  32.6065500000001E-18 M=1.0
C3137 VD 96  32.6065499999999E-18 M=1.0
C3138 VD 95  32.60655E-18 M=1.0
C3139 VD 94  32.6065499999999E-18 M=1.0
C3140 VD 93  32.6065500000001E-18 M=1.0
C3141 VD 21  32.6065500000001E-18 M=1.0
C3142 VD 20  32.6065499999999E-18 M=1.0
C3143 VD 19  32.60655E-18 M=1.0
C3144 VD 18  32.6065499999999E-18 M=1.0
C3145 VD 17  32.6065500000001E-18 M=1.0
C3146 VD A0ININ  295.423200000001E-18 M=1.0
C3147 362 431  75.2328E-18 M=1.0
C3148 362 427  75.2328E-18 M=1.0
C3149 362 423  75.2328E-18 M=1.0
C3150 358 431  75.2328E-18 M=1.0
C3151 358 427  75.2328E-18 M=1.0
C3152 358 423  75.2328E-18 M=1.0
C3153 354 431  75.2328E-18 M=1.0
C3154 354 427  75.2328E-18 M=1.0
C3155 354 423  75.2328E-18 M=1.0
C3156 350 431  75.2328E-18 M=1.0
C3157 350 427  75.2328E-18 M=1.0
C3158 350 423  75.2328E-18 M=1.0
C3159 129 423  75.2328E-18 M=1.0
C3160 128 423  75.2328E-18 M=1.0
C3161 127 423  75.2328E-18 M=1.0
C3162 126 423  75.2328E-18 M=1.0
C3163 125 423  75.2328E-18 M=1.0
C3164 97 427  75.2328E-18 M=1.0
C3165 96 427  75.2328E-18 M=1.0
C3166 95 427  75.2328E-18 M=1.0
C3167 94 427  75.2328E-18 M=1.0
C3168 93 427  75.2328E-18 M=1.0
C3169 21 431  75.2328E-18 M=1.0
C3170 20 431  75.2328E-18 M=1.0
C3171 19 431  75.2328E-18 M=1.0
C3172 18 431  75.2328E-18 M=1.0
C3173 17 431  75.2328E-18 M=1.0
C3174 GD 427  3.5809794E-15 M=1.0
C3175 GD 354  316.7037E-18 M=1.0
C3176 GD 129  78.5412E-18 M=1.0
C3177 GD 128  78.5412E-18 M=1.0
C3178 GD 127  78.5412E-18 M=1.0
C3179 GD 126  78.5412E-18 M=1.0
C3180 GD 125  78.5412E-18 M=1.0
C3181 GD 105  60.6456E-18 M=1.0
C3182 GD 104  60.6456E-18 M=1.0
C3183 GD 103  60.6456E-18 M=1.0
C3184 GD 102  133.0416E-18 M=1.0
C3185 GD 97  78.5412E-18 M=1.0
C3186 GD 96  78.5412E-18 M=1.0
C3187 GD 95  78.5412E-18 M=1.0
C3188 GD 94  78.5412E-18 M=1.0
C3189 GD 93  78.5412E-18 M=1.0
C3190 GD 29  60.6456E-18 M=1.0
C3191 GD 25  60.6456E-18 M=1.0
C3192 GD 21  78.5412E-18 M=1.0
C3193 GD 20  78.5412E-18 M=1.0
C3194 GD 19  78.5412E-18 M=1.0
C3195 GD 18  78.5412E-18 M=1.0
C3196 GD 17  78.5412E-18 M=1.0
C3197 A0ININ 431  75.2328E-18 M=1.0
C3198 A0ININ 427  75.2328E-18 M=1.0
C3199 A0ININ 423  75.2328E-18 M=1.0
C3200 VD 137  34.2306E-18 M=1.0
C3201 VD 136  34.2306E-18 M=1.0
C3202 VD 135  34.2306E-18 M=1.0
C3203 VD 134  34.2306E-18 M=1.0
C3204 VD 133  34.2306E-18 M=1.0
C3205 VD 129  56.0232E-18 M=1.0
C3206 VD 128  56.0232E-18 M=1.0
C3207 VD 127  56.0232E-18 M=1.0
C3208 VD 126  56.0232E-18 M=1.0
C3209 VD 125  56.0232E-18 M=1.0
C3210 VD 103  106.6266E-18 M=1.0
C3211 VD 102  34.2306E-18 M=1.0
C3212 VD 101  34.2306E-18 M=1.0
C3213 VD 97  56.0232E-18 M=1.0
C3214 VD 96  56.0232E-18 M=1.0
C3215 VD 95  56.0232E-18 M=1.0
C3216 VD 94  56.0232E-18 M=1.0
C3217 VD 93  56.0232E-18 M=1.0
C3218 VD 28  34.2306E-18 M=1.0
C3219 VD 27  34.2306E-18 M=1.0
C3220 VD 26  34.2306E-18 M=1.0
C3221 VD 21  56.0232E-18 M=1.0
C3222 VD 20  56.0232E-18 M=1.0
C3223 VD 19  56.0232E-18 M=1.0
C3224 VD 18  56.0232E-18 M=1.0
C3225 VD 17  56.0232E-18 M=1.0
C3226 362 431  34.9776E-18 M=1.0
C3227 362 427  90.3762E-18 M=1.0
C3228 362 423  131.3055E-18 M=1.0
C3229 358 431  34.9776E-18 M=1.0
C3230 358 427  34.9776E-18 M=1.0
C3231 358 423  90.3762E-18 M=1.0
C3232 354 431  34.9776E-18 M=1.0
C3233 354 427  34.9776E-18 M=1.0
C3234 354 423  34.9776E-18 M=1.0
C3235 350 431  34.9776E-18 M=1.0
C3236 350 427  34.9776E-18 M=1.0
C3237 350 423  34.9776E-18 M=1.0
C3238 137 350  65.5065E-18 M=1.0
C3239 136 354  65.5065E-18 M=1.0
C3240 135 358  65.5065E-18 M=1.0
C3241 134 362  65.5065E-18 M=1.0
C3242 129 350  100.9458E-18 M=1.0
C3243 128 354  100.9458E-18 M=1.0
C3244 127 358  100.9458E-18 M=1.0
C3245 126 362  100.9458E-18 M=1.0
C3246 105 350  65.5065E-18 M=1.0
C3247 104 354  65.5065E-18 M=1.0
C3248 103 358  65.5065E-18 M=1.0
C3249 102 362  65.5065E-18 M=1.0
C3250 97 350  100.9458E-18 M=1.0
C3251 96 354  100.9458E-18 M=1.0
C3252 95 358  100.9458E-18 M=1.0
C3253 94 362  100.9458E-18 M=1.0
C3254 29 350  65.5065E-18 M=1.0
C3255 28 427  34.9776E-18 M=1.0
C3256 28 423  34.9776E-18 M=1.0
C3257 28 358  104.9328E-18 M=1.0
C3258 28 354  65.5065E-18 M=1.0
C3259 28 135  55.2771E-18 M=1.0
C3260 28 127  90.8703E-18 M=1.0
C3261 28 103  55.2771E-18 M=1.0
C3262 28 95  90.8703E-18 M=1.0
C3263 27 358  65.5065E-18 M=1.0
C3264 26 362  65.5065E-18 M=1.0
C3265 21 350  100.9458E-18 M=1.0
C3266 20 354  100.9458E-18 M=1.0
C3267 19 358  100.9458E-18 M=1.0
C3268 18 362  100.9458E-18 M=1.0
C3269 GD 25  5.8845276E-15 M=1.0
C3270 A0ININ 133  65.5065E-18 M=1.0
C3271 A0ININ 125  100.9458E-18 M=1.0
C3272 A0ININ 101  65.5065E-18 M=1.0
C3273 A0ININ 93  100.9458E-18 M=1.0
C3274 A0ININ 25  65.5065E-18 M=1.0
C3275 A0ININ 17  100.9458E-18 M=1.0
C3276 358 362  104.6088E-18 M=1.0
C3277 354 362  104.6088E-18 M=1.0
C3278 350 358  104.6088E-18 M=1.0
C3279 350 354  104.6088E-18 M=1.0
C3280 346 362  104.6088E-18 M=1.0
C3281 346 358  104.6088E-18 M=1.0
C3282 346 354  104.6088E-18 M=1.0
C3283 346 350  104.6088E-18 M=1.0
C3284 342 358  104.6088E-18 M=1.0
C3285 342 354  104.6088E-18 M=1.0
C3286 338 362  104.6088E-18 M=1.0
C3287 338 358  104.6088E-18 M=1.0
C3288 338 354  104.6088E-18 M=1.0
C3289 338 350  104.6088E-18 M=1.0
C3290 136 350  52.3044E-18 M=1.0
C3291 127 135  159.85305E-18 M=1.0
C3292 104 350  52.3044E-18 M=1.0
C3293 103 354  52.3044E-18 M=1.0
C3294 103 350  52.3044E-18 M=1.0
C3295 102 362  104.6088E-18 M=1.0
C3296 101 362  52.3044E-18 M=1.0
C3297 101 358  52.3044E-18 M=1.0
C3298 101 354  52.3044E-18 M=1.0
C3299 101 350  52.3044E-18 M=1.0
C3300 94 102  133.89885E-18 M=1.0
C3301 93 102  140.569425E-18 M=1.0
C3302 28 103  52.3044E-18 M=1.0
C3303 28 101  52.3044E-18 M=1.0
C3304 27 354  52.3044E-18 M=1.0
C3305 27 350  52.3044E-18 M=1.0
C3306 27 28  52.3044E-18 M=1.0
C3307 26 358  52.3044E-18 M=1.0
C3308 26 354  52.3044E-18 M=1.0
C3309 26 350  52.3044E-18 M=1.0
C3310 26 28  52.3044E-18 M=1.0
C3311 GD 354  2.8680669E-15 M=1.0
C3312 GD 350  3.43478115E-15 M=1.0
C3313 GD 346  4.00642335E-15 M=1.0
C3314 GD 338  5.12999595E-15 M=1.0
C3315 GD 135  4.2843681E-15 M=1.0
C3316 GD 102  6.160205475E-15 M=1.0
C3317 GD 26  5.55783975E-15 M=1.0
C3318 A0ININ 358  104.6088E-18 M=1.0
C3319 A0ININ 354  104.6088E-18 M=1.0
C3320 A0ININ 350  104.6088E-18 M=1.0
C3321 A0ININ 342  104.6088E-18 M=1.0
C3322 A0ININ 338  104.6088E-18 M=1.0
C3323 A0ININ 102  104.6088E-18 M=1.0
C3324 VD 137  514.8783E-18 M=1.0
C3325 VD 103  668.6748E-18 M=1.0
C3326 362 431  133.7067E-18 M=1.0
C3327 362 427  133.7067E-18 M=1.0
C3328 362 423  133.7067E-18 M=1.0
C3329 358 431  125.2908E-18 M=1.0
C3330 358 427  125.2908E-18 M=1.0
C3331 358 423  125.2908E-18 M=1.0
C3332 354 431  129.49875E-18 M=1.0
C3333 354 427  129.49875E-18 M=1.0
C3334 354 423  129.49875E-18 M=1.0
C3335 350 431  125.2908E-18 M=1.0
C3336 350 427  125.2908E-18 M=1.0
C3337 350 423  125.2908E-18 M=1.0
C3338 135 423  329.723325E-18 M=1.0
C3339 135 362  49.5477E-18 M=1.0
C3340 135 358  49.5477E-18 M=1.0
C3341 126 135  44.3223E-18 M=1.0
C3342 125 135  44.3223E-18 M=1.0
C3343 102 135  58.6386E-18 M=1.0
C3344 28 427  49.5477E-18 M=1.0
C3345 28 423  49.5477E-18 M=1.0
C3346 25 427  49.5477E-18 M=1.0
C3347 25 423  49.5477E-18 M=1.0
C3348 25 135  49.5477E-18 M=1.0
C3349 GD 431  2.218734E-15 M=1.0
C3350 GD 423  1.9422927E-15 M=1.0
C3351 GD 135  690.0156E-18 M=1.0
C3352 A0ININ 431  142.1226E-18 M=1.0
C3353 A0ININ 427  142.1226E-18 M=1.0
C3354 A0ININ 423  142.1226E-18 M=1.0
C3355 A0ININ 135  49.5477E-18 M=1.0
C3356 VD 431  1.0404432E-15 M=1.0
C3357 VD 427  1.0404432E-15 M=1.0
C3358 VD 423  1.0404432E-15 M=1.0
C3359 VD 135  465.5493E-18 M=1.0
C3360 GD 169  282.851999999999E-18 M=1.0
C3361 GD 168  282.851999999999E-18 M=1.0
C3362 GD 136  209.781900000001E-18 M=1.0
C3363 VD 169  53.4276E-18 M=1.0
C3364 VD 168  53.4276E-18 M=1.0
C3365 VD 137  40.0707E-18 M=1.0
C3366 GD 169  133.0416E-18 M=1.0
C3367 GD 168  133.0416E-18 M=1.0
C3368 VD 232  30.4272000000001E-18 M=1.0
C3369 VD 195  30.4271999999999E-18 M=1.0
C3370 232 816  69.2001E-18 M=1.0
C3371 195 803  69.2001E-18 M=1.0
C3372 194 195  69.2001E-18 M=1.0
C3373 169 816  34.9776E-18 M=1.0
C3374 168 803  34.9776E-18 M=1.0
C3375 168 194  34.9776E-18 M=1.0
C3376 146 168  174.888E-18 M=1.0
C3377 137 816  34.9776E-18 M=1.0
C3378 136 803  34.9776E-18 M=1.0
C3379 136 194  34.9776E-18 M=1.0
C3380 136 168  174.888E-18 M=1.0
C3381 A0ININ 431  90.3762E-18 M=1.0
C3382 A0ININ 427  90.3762E-18 M=1.0
C3383 A0ININ 423  90.3762E-18 M=1.0
C3384 A0ININ GD  38.12845095E-15 M=1.0
C3385 VD 146  689.1111E-18 M=1.0
C3386 A7B3 GD  6.6947481E-15 M=1.0
C3387 169 816  52.3044E-18 M=1.0
C3388 169 431  37.6677E-18 M=1.0
C3389 169 427  37.6677E-18 M=1.0
C3390 169 423  37.6677E-18 M=1.0
C3391 169 419  68.84685E-18 M=1.0
C3392 169 195  96.408E-18 M=1.0
C3393 169 194  52.3044E-18 M=1.0
C3394 168 803  52.3044E-18 M=1.0
C3395 166 431  37.6677E-18 M=1.0
C3396 166 427  37.6677E-18 M=1.0
C3397 166 168  52.3044E-18 M=1.0
C3398 165 431  37.6677E-18 M=1.0
C3399 165 427  37.6677E-18 M=1.0
C3400 165 168  52.3044E-18 M=1.0
C3401 164 431  37.6677E-18 M=1.0
C3402 164 427  37.6677E-18 M=1.0
C3403 164 168  52.3044E-18 M=1.0
C3404 147 431  37.6677E-18 M=1.0
C3405 147 427  37.6677E-18 M=1.0
C3406 147 195  44.1036E-18 M=1.0
C3407 147 169  52.3044E-18 M=1.0
C3408 147 168  103.5792E-18 M=1.0
C3409 146 168  52.3044E-18 M=1.0
C3410 137 816  52.6203E-18 M=1.0
C3411 137 431  37.6677E-18 M=1.0
C3412 137 427  37.6677E-18 M=1.0
C3413 137 423  37.6677E-18 M=1.0
C3414 137 419  37.6677E-18 M=1.0
C3415 137 147  52.3044E-18 M=1.0
C3416 136 803  52.6203E-18 M=1.0
C3417 136 431  37.6677E-18 M=1.0
C3418 136 166  52.3044E-18 M=1.0
C3419 136 165  52.3044E-18 M=1.0
C3420 136 164  52.3044E-18 M=1.0
C3421 136 147  77.9418E-18 M=1.0
C3422 136 146  52.3044E-18 M=1.0
C3423 103 427  1.12971285E-15 M=1.0
C3424 103 423  37.6677E-18 M=1.0
C3425 103 419  37.6677E-18 M=1.0
C3426 103 362  52.3044E-18 M=1.0
C3427 26 423  37.6677E-18 M=1.0
C3428 26 419  37.6677E-18 M=1.0
C3429 26 362  52.3044E-18 M=1.0
C3430 GD 169  2.7963018E-15 M=1.0
C3431 GD 168  2.90248065E-15 M=1.0
C3432 GD 166  7.177338E-15 M=1.0
C3433 GD 147  5.2359264E-15 M=1.0
C3434 A0ININ 169  52.3044E-18 M=1.0
C3435 A0ININ 168  52.3044E-18 M=1.0
C3436 A0ININ 147  104.6088E-18 M=1.0
C3437 A0ININ 137  52.3044E-18 M=1.0
C3438 A0ININ 136  52.3044E-18 M=1.0
C3439 A0ININ 103  52.3044E-18 M=1.0
C3440 A0ININ 27  52.3044E-18 M=1.0
C3441 A0ININ 26  52.3044E-18 M=1.0
C3442 VD 168  313.9407E-18 M=1.0
C3443 VD 136  377.8434E-18 M=1.0
C3444 166 431  37.3761E-18 M=1.0
C3445 166 427  37.3761E-18 M=1.0
C3446 166 168  49.5477E-18 M=1.0
C3447 165 431  37.3761E-18 M=1.0
C3448 165 427  37.3761E-18 M=1.0
C3449 165 168  49.5477E-18 M=1.0
C3450 164 431  37.3761E-18 M=1.0
C3451 164 427  37.3761E-18 M=1.0
C3452 164 168  49.5477E-18 M=1.0
C3453 147 423  791.6814E-18 M=1.0
C3454 147 419  37.3761E-18 M=1.0
C3455 147 169  58.6386000000001E-18 M=1.0
C3456 146 431  37.3761E-18 M=1.0
C3457 146 427  767.74005E-18 M=1.0
C3458 146 423  37.3761E-18 M=1.0
C3459 146 419  37.3761E-18 M=1.0
C3460 146 169  58.6386000000001E-18 M=1.0
C3461 146 168  58.6386E-18 M=1.0
C3462 146 147  58.6386E-18 M=1.0
C3463 137 147  58.6386E-18 M=1.0
C3464 137 146  58.6386E-18 M=1.0
C3465 136 166  49.5477E-18 M=1.0
C3466 136 165  49.5477E-18 M=1.0
C3467 136 164  49.5477E-18 M=1.0
C3468 136 146  58.6386E-18 M=1.0
C3469 134 431  37.3761E-18 M=1.0
C3470 134 427  37.3761E-18 M=1.0
C3471 134 423  37.3761E-18 M=1.0
C3472 134 419  21.8574E-18 M=1.0
C3473 134 169  49.5477E-18 M=1.0
C3474 134 168  49.5477E-18 M=1.0
C3475 134 137  49.5477E-18 M=1.0
C3476 134 136  49.5477E-18 M=1.0
C3477 133 431  37.3761E-18 M=1.0
C3478 133 427  37.3761E-18 M=1.0
C3479 133 423  37.3761E-18 M=1.0
C3480 133 419  21.8574E-18 M=1.0
C3481 133 169  49.5477E-18 M=1.0
C3482 133 168  49.5477E-18 M=1.0
C3483 133 137  49.5477E-18 M=1.0
C3484 133 136  49.5477E-18 M=1.0
C3485 116 431  37.3761E-18 M=1.0
C3486 116 362  49.5477E-18 M=1.0
C3487 116 169  58.6386000000001E-18 M=1.0
C3488 116 168  58.6386E-18 M=1.0
C3489 116 147  58.6386E-18 M=1.0
C3490 116 146  58.6386E-18 M=1.0
C3491 116 137  58.6386E-18 M=1.0
C3492 116 136  58.6386E-18 M=1.0
C3493 104 134  49.5477E-18 M=1.0
C3494 104 133  49.5477E-18 M=1.0
C3495 103 431  37.3761E-18 M=1.0
C3496 103 427  37.3761E-18 M=1.0
C3497 103 423  37.3761E-18 M=1.0
C3498 103 419  21.8574E-18 M=1.0
C3499 103 169  58.6386000000001E-18 M=1.0
C3500 103 168  49.5477E-18 M=1.0
C3501 103 147  58.6386E-18 M=1.0
C3502 103 146  58.6386E-18 M=1.0
C3503 103 137  58.6386E-18 M=1.0
C3504 103 136  58.6386E-18 M=1.0
C3505 103 116  58.6386E-18 M=1.0
C3506 103 104  58.6386E-18 M=1.0
C3507 101 431  37.3761E-18 M=1.0
C3508 101 427  37.3761E-18 M=1.0
C3509 101 423  37.3761E-18 M=1.0
C3510 101 419  20.272725E-18 M=1.0
C3511 101 169  87.67935E-18 M=1.0
C3512 101 168  49.5477E-18 M=1.0
C3513 101 137  87.67935E-18 M=1.0
C3514 101 136  87.67935E-18 M=1.0
C3515 101 104  49.5477E-18 M=1.0
C3516 29 431  37.3761E-18 M=1.0
C3517 29 427  37.3761E-18 M=1.0
C3518 29 423  37.3761E-18 M=1.0
C3519 29 419  21.8574E-18 M=1.0
C3520 29 169  58.6386000000001E-18 M=1.0
C3521 29 168  49.5477E-18 M=1.0
C3522 29 137  58.6386E-18 M=1.0
C3523 29 136  58.6386E-18 M=1.0
C3524 29 104  58.6386E-18 M=1.0
C3525 27 134  49.5477E-18 M=1.0
C3526 27 133  49.5477E-18 M=1.0
C3527 27 103  58.6386E-18 M=1.0
C3528 27 101  49.5477E-18 M=1.0
C3529 27 29  58.6386E-18 M=1.0
C3530 26 147  58.6386E-18 M=1.0
C3531 26 146  58.6386E-18 M=1.0
C3532 26 134  49.5477E-18 M=1.0
C3533 26 133  49.5477E-18 M=1.0
C3534 26 116  58.6386E-18 M=1.0
C3535 26 101  87.67935E-18 M=1.0
C3536 26 29  58.6386E-18 M=1.0
C3537 GD 134  8.3053296E-15 M=1.0
C3538 GD 103  2.253384E-15 M=1.0
C3539 A7B3 431  37.3761E-18 M=1.0
C3540 A7B3 427  37.3761E-18 M=1.0
C3541 A7B3 423  37.3761E-18 M=1.0
C3542 A7B3 419  845.47665E-18 M=1.0
C3543 A7B3 169  58.6386000000001E-18 M=1.0
C3544 A7B3 168  49.5477E-18 M=1.0
C3545 A7B3 137  58.6386E-18 M=1.0
C3546 A7B3 136  58.6386E-18 M=1.0
C3547 A7B3 104  58.6386E-18 M=1.0
C3548 A7B3 103  58.6386E-18 M=1.0
C3549 A7B3 27  58.6386E-18 M=1.0
C3550 A7B3 26  58.6386E-18 M=1.0
C3551 104 166  52.3044E-18 M=1.0
C3552 104 165  52.3044E-18 M=1.0
C3553 104 164  52.3044E-18 M=1.0
C3554 27 166  52.3044E-18 M=1.0
C3555 27 165  52.3044E-18 M=1.0
C3556 27 164  52.3044E-18 M=1.0
C3557 104 166  49.5477E-18 M=1.0
C3558 104 165  49.5477E-18 M=1.0
C3559 104 164  49.5477E-18 M=1.0
C3560 27 166  49.5477E-18 M=1.0
C3561 27 165  49.5477E-18 M=1.0
C3562 27 164  49.5477E-18 M=1.0
C3563 VD 26  55.3986E-18 M=1.0
C3564 166 423  37.6677E-18 M=1.0
C3565 166 419  22.0518E-18 M=1.0
C3566 166 169  52.3044E-18 M=1.0
C3567 165 423  37.6677E-18 M=1.0
C3568 165 419  22.0518E-18 M=1.0
C3569 165 169  52.3044E-18 M=1.0
C3570 164 423  37.6677E-18 M=1.0
C3571 164 419  22.0518E-18 M=1.0
C3572 164 169  52.3044E-18 M=1.0
C3573 137 166  52.3044E-18 M=1.0
C3574 137 165  52.3044E-18 M=1.0
C3575 137 164  52.3044E-18 M=1.0
C3576 26 166  52.3044E-18 M=1.0
C3577 26 165  52.3044E-18 M=1.0
C3578 26 164  52.3044E-18 M=1.0
C3579 GD 164  6.616575675E-15 M=1.0
C3580 166 423  37.3761E-18 M=1.0
C3581 166 419  21.8574E-18 M=1.0
C3582 166 169  49.5477E-18 M=1.0
C3583 165 423  37.3761E-18 M=1.0
C3584 165 419  21.8574E-18 M=1.0
C3585 165 169  49.5477E-18 M=1.0
C3586 164 423  37.3761E-18 M=1.0
C3587 164 419  21.8574E-18 M=1.0
C3588 164 169  49.5477E-18 M=1.0
C3589 137 166  49.5477E-18 M=1.0
C3590 137 165  49.5477E-18 M=1.0
C3591 137 164  49.5477E-18 M=1.0
C3592 26 166  49.5477E-18 M=1.0
C3593 26 165  49.5477E-18 M=1.0
C3594 26 164  49.5477E-18 M=1.0
C3595 GD 202  139.8546E-18 M=1.0
C3596 GD 197  69.9273E-18 M=1.0
C3597 GD 146  254.566800000001E-18 M=1.0
C3598 GD 138  209.7819E-18 M=1.0
C3599 VD 202  26.7138E-18 M=1.0
C3600 VD 147  81.7128E-18 M=1.0
C3601 VD 146  81.7128000000003E-18 M=1.0
C3602 VD 138  40.0707E-18 M=1.0
C3603 VD A6B4  53.4276E-18 M=1.0
C3604 GD 202  214.7382E-18 M=1.0
C3605 GD 197  189.5436E-18 M=1.0
C3606 GD 194  44.0135999999999E-18 M=1.0
C3607 GD 172  44.0136E-18 M=1.0
C3608 GD 138  136.2294E-18 M=1.0
C3609 VD 197  30.4271999999999E-18 M=1.0
C3610 VD 171  30.4271999999999E-18 M=1.0
C3611 VD 170  30.4271999999999E-18 M=1.0
C3612 VD 146  106.6266E-18 M=1.0
C3613 197 202  135E-18 M=1.0
C3614 171 202  65.0448E-18 M=1.0
C3615 147 816  69.9552E-18 M=1.0
C3616 146 803  69.9552E-18 M=1.0
C3617 146 194  69.9552E-18 M=1.0
C3618 138 804  34.9776E-18 M=1.0
C3619 138 197  100.0224E-18 M=1.0
C3620 138 172  34.9776E-18 M=1.0
C3621 GD 202  799.4889E-18 M=1.0
C3622 GD 197  326.322E-18 M=1.0
C3623 GD 194  66.4299E-18 M=1.0
C3624 GD 172  65.9682E-18 M=1.0
C3625 GD 138  6.1455852E-15 M=1.0
C3626 A6B4 197  100.0224E-18 M=1.0
C3627 A6B4 138  174.888E-18 M=1.0
C3628 VD 816  66.4299E-18 M=1.0
C3629 VD 804  65.9682E-18 M=1.0
C3630 VD 803  66.4299E-18 M=1.0
C3631 A7B3 804  34.9776E-18 M=1.0
C3632 A7B3 202  169.9776E-18 M=1.0
C3633 A7B3 197  100.0224E-18 M=1.0
C3634 A7B3 172  34.9776E-18 M=1.0
C3635 A7B3 A6B4  174.888E-18 M=1.0
C3636 171 197  69.741E-18 M=1.0
C3637 170 202  51.2748E-18 M=1.0
C3638 170 197  69.741E-18 M=1.0
C3639 170 171  44.1036E-18 M=1.0
C3640 147 816  52.3044E-18 M=1.0
C3641 147 194  52.3044E-18 M=1.0
C3642 146 803  52.3044E-18 M=1.0
C3643 138 171  76.9122E-18 M=1.0
C3644 138 170  40.9032E-18 M=1.0
C3645 GD 171  3.29595615E-15 M=1.0
C3646 A6B4 170  25.6374E-18 M=1.0
C3647 VD 170  545.4333E-18 M=1.0
C3648 VD 147  610.720875E-18 M=1.0
C3649 VD 146  378.56205E-18 M=1.0
C3650 VD 116  1.354396275E-15 M=1.0
C3651 A7B3 171  102.5496E-18 M=1.0
C3652 A7B3 170  137.1636E-18 M=1.0
C3653 202 227  567.429075E-18 M=1.0
C3654 197 227  77.8167E-18 M=1.0
C3655 170 227  129.8106E-18 M=1.0
C3656 138 227  137.7333E-18 M=1.0
C3657 VD 227  124.1901E-18 M=1.0
C3658 A7B3 227  122.9598E-18 M=1.0
C3659 GD 195  139.8546E-18 M=1.0
C3660 GD 193  69.9273000000005E-18 M=1.0
C3661 GD 189  69.9272999999993E-18 M=1.0
C3662 GD 188  69.9272999999998E-18 M=1.0
C3663 GD 40  204.282000000001E-18 M=1.0
C3664 GD 26  282.852000000001E-18 M=1.0
C3665 VD 232  26.7138000000001E-18 M=1.0
C3666 VD 195  26.7137999999998E-18 M=1.0
C3667 VD 136  40.0707000000004E-18 M=1.0
C3668 VD 103  81.7127999999999E-18 M=1.0
C3669 GD 195  214.7382E-18 M=1.0
C3670 GD 193  189.5436E-18 M=1.0
C3671 GD 192  44.0136E-18 M=1.0
C3672 GD 191  164.349E-18 M=1.0
C3673 GD 189  189.5436E-18 M=1.0
C3674 GD 188  189.5436E-18 M=1.0
C3675 GD 136  136.2294E-18 M=1.0
C3676 GD 26  133.0416E-18 M=1.0
C3677 VD 230  30.4271999999999E-18 M=1.0
C3678 VD 228  102.8232E-18 M=1.0
C3679 VD 227  30.4272E-18 M=1.0
C3680 VD 226  30.4272E-18 M=1.0
C3681 VD 193  30.4272000000001E-18 M=1.0
C3682 VD 190  30.4272E-18 M=1.0
C3683 VD 189  30.4272000000001E-18 M=1.0
C3684 VD 188  30.4272E-18 M=1.0
C3685 VD 147  106.6266E-18 M=1.0
C3686 226 814  69.2001E-18 M=1.0
C3687 193 195  135E-18 M=1.0
C3688 191 195  65.0448E-18 M=1.0
C3689 189 799  34.9776E-18 M=1.0
C3690 188 799  34.9776E-18 M=1.0
C3691 188 189  100.0224E-18 M=1.0
C3692 187 814  34.9776E-18 M=1.0
C3693 169 232  204.9552E-18 M=1.0
C3694 168 195  204.9552E-18 M=1.0
C3695 168 193  100.0224E-18 M=1.0
C3696 147 815  34.9776E-18 M=1.0
C3697 147 232  169.9776E-18 M=1.0
C3698 147 169  174.888E-18 M=1.0
C3699 146 802  34.9776E-18 M=1.0
C3700 146 195  169.9776E-18 M=1.0
C3701 146 193  100.0224E-18 M=1.0
C3702 146 192  34.9776E-18 M=1.0
C3703 137 815  34.9776E-18 M=1.0
C3704 137 169  174.888E-18 M=1.0
C3705 137 147  139.9104E-18 M=1.0
C3706 136 802  34.9776E-18 M=1.0
C3707 136 195  139.9104E-18 M=1.0
C3708 136 193  100.0224E-18 M=1.0
C3709 136 192  34.9776E-18 M=1.0
C3710 136 146  139.9104E-18 M=1.0
C3711 115 189  69.9552E-18 M=1.0
C3712 115 188  100.0224E-18 M=1.0
C3713 103 814  69.9552E-18 M=1.0
C3714 40 189  100.0224E-18 M=1.0
C3715 40 188  100.0224E-18 M=1.0
C3716 26 814  34.9776E-18 M=1.0
C3717 26 187  174.888E-18 M=1.0
C3718 26 103  174.888E-18 M=1.0
C3719 GD 195  799.4889E-18 M=1.0
C3720 GD 193  326.322E-18 M=1.0
C3721 GD 192  65.9682E-18 M=1.0
C3722 GD 189  230.8167E-18 M=1.0
C3723 GD 188  146.8449E-18 M=1.0
C3724 GD 169  1.7997714E-15 M=1.0
C3725 GD 168  2.9838051E-15 M=1.0
C3726 GD 136  3.8613312E-15 M=1.0
C3727 VD 815  65.9682E-18 M=1.0
C3728 VD 814  66.4299E-18 M=1.0
C3729 VD 802  65.9682E-18 M=1.0
C3730 VD 799  65.9682E-18 M=1.0
C3731 VD 147  689.1111E-18 M=1.0
C3732 VD 103  689.1111E-18 M=1.0
C3733 VD 40  527.5539E-18 M=1.0
C3734 146 169  95.3766000000001E-18 M=1.0
C3735 137 195  52.3044E-18 M=1.0
C3736 137 193  73.2384E-18 M=1.0
C3737 137 168  135.1404E-18 M=1.0
C3738 137 146  67.5702E-18 M=1.0
C3739 136 169  77.9418E-18 M=1.0
C3740 103 814  52.6203E-18 M=1.0
C3741 40 115  52.3044E-18 M=1.0
C3742 26 814  52.3044E-18 M=1.0
C3743 26 189  439.3539E-18 M=1.0
C3744 26 103  104.6088E-18 M=1.0
C3745 26 40  52.3044E-18 M=1.0
C3746 GD 190  77.1624E-18 M=1.0
C3747 GD 137  3.3312339E-15 M=1.0
C3748 VD 169  460.1997E-18 M=1.0
C3749 VD 115  488.0502E-18 M=1.0
C3750 VD 26  563.11785E-18 M=1.0
C3751 191 431  49.5477E-18 M=1.0
C3752 191 362  49.5477E-18 M=1.0
C3753 191 195  21.0402E-18 M=1.0
C3754 190 191  44.4438E-18 M=1.0
C3755 189 191  36.7209E-18 M=1.0
C3756 188 191  64.917E-18 M=1.0
C3757 185 189  36.5589E-18 M=1.0
C3758 185 188  64.755E-18 M=1.0
C3759 115 191  113.39415E-18 M=1.0
C3760 115 185  99.118575E-18 M=1.0
C3761 103 191  58.6386E-18 M=1.0
C3762 103 185  495.74835E-18 M=1.0
C3763 40 814  46.251E-18 M=1.0
C3764 40 185  100.719E-18 M=1.0
C3765 40 103  344.8323E-18 M=1.0
C3766 26 191  58.6386E-18 M=1.0
C3767 26 185  58.6386E-18 M=1.0
C3768 GD 191  113.0328E-18 M=1.0
C3769 GD 190  1.8032598E-15 M=1.0
C3770 GD 185  652.968E-18 M=1.0
C3771 VD 191  531.1152E-18 M=1.0
C3772 VD 220  26.7138E-18 M=1.0
C3773 VD 218  30.4272E-18 M=1.0
C3774 362 419  55.3986E-18 M=1.0
C3775 358 419  55.3986E-18 M=1.0
C3776 354 419  55.3986E-18 M=1.0
C3777 191 220  169.9776E-18 M=1.0
C3778 179 191  174.888E-18 M=1.0
C3779 GD 28  6.1373754E-15 M=1.0
C3780 A0ININ 419  55.3986E-18 M=1.0
C3781 179 218  61.35075E-18 M=1.0
C3782 173 218  72.11025E-18 M=1.0
C3783 167 415  37.6677E-18 M=1.0
C3784 167 362  52.3044E-18 M=1.0
C3785 167 358  52.3044E-18 M=1.0
C3786 167 354  52.3044E-18 M=1.0
C3787 167 350  52.3044E-18 M=1.0
C3788 145 415  37.6677E-18 M=1.0
C3789 145 350  70.614E-18 M=1.0
C3790 135 415  37.6677E-18 M=1.0
C3791 135 362  52.3044E-18 M=1.0
C3792 135 358  52.3044E-18 M=1.0
C3793 135 354  52.3044E-18 M=1.0
C3794 135 350  52.3044E-18 M=1.0
C3795 102 415  37.6677E-18 M=1.0
C3796 102 358  52.3044E-18 M=1.0
C3797 102 354  52.3044E-18 M=1.0
C3798 102 350  52.3044E-18 M=1.0
C3799 28 419  37.6677E-18 M=1.0
C3800 28 362  52.3044E-18 M=1.0
C3801 25 362  52.3044E-18 M=1.0
C3802 25 358  52.3044E-18 M=1.0
C3803 25 354  52.3044E-18 M=1.0
C3804 GD 28  2.91435525E-15 M=1.0
C3805 A0ININ 167  52.3044E-18 M=1.0
C3806 A0ININ 135  52.3044E-18 M=1.0
C3807 A0ININ 28  52.3044E-18 M=1.0
C3808 A0ININ 25  104.6088E-18 M=1.0
C3809 VD 173  538.6158E-18 M=1.0
C3810 147 362  49.5477E-18 M=1.0
C3811 147 358  1.143726075E-15 M=1.0
C3812 147 167  58.6386E-18 M=1.0
C3813 146 362  49.5477E-18 M=1.0
C3814 146 358  49.5477E-18 M=1.0
C3815 146 354  1.16465445E-15 M=1.0
C3816 146 167  58.6386E-18 M=1.0
C3817 145 350  897.3342E-18 M=1.0
C3818 145 167  58.6386E-18 M=1.0
C3819 135 147  58.6386E-18 M=1.0
C3820 135 146  58.6386E-18 M=1.0
C3821 135 145  58.6386E-18 M=1.0
C3822 134 167  58.6386E-18 M=1.0
C3823 134 135  58.6386E-18 M=1.0
C3824 133 167  58.6386E-18 M=1.0
C3825 133 135  58.6386E-18 M=1.0
C3826 116 423  37.3761E-18 M=1.0
C3827 116 419  49.5477E-18 M=1.0
C3828 116 415  625.83885E-18 M=1.0
C3829 116 358  49.5477E-18 M=1.0
C3830 116 354  49.5477E-18 M=1.0
C3831 116 350  49.5477E-18 M=1.0
C3832 116 167  58.6386E-18 M=1.0
C3833 116 145  58.6386E-18 M=1.0
C3834 116 135  58.6386E-18 M=1.0
C3835 102 147  58.6386E-18 M=1.0
C3836 102 146  58.6386E-18 M=1.0
C3837 102 134  58.6386E-18 M=1.0
C3838 102 133  58.6386E-18 M=1.0
C3839 102 116  58.6386E-18 M=1.0
C3840 101 167  58.6386E-18 M=1.0
C3841 101 135  58.6386E-18 M=1.0
C3842 101 102  58.6386E-18 M=1.0
C3843 28 147  58.6386E-18 M=1.0
C3844 28 146  58.6386E-18 M=1.0
C3845 28 134  49.5477E-18 M=1.0
C3846 28 133  49.5477E-18 M=1.0
C3847 28 116  58.6386E-18 M=1.0
C3848 28 101  58.6386E-18 M=1.0
C3849 25 147  58.6386E-18 M=1.0
C3850 25 146  58.6386E-18 M=1.0
C3851 25 134  49.5477E-18 M=1.0
C3852 25 133  49.5477E-18 M=1.0
C3853 25 116  58.6386E-18 M=1.0
C3854 25 101  49.5477E-18 M=1.0
C3855 GD 101  8.2882872E-15 M=1.0
C3856 A0ININ 147  49.5477E-18 M=1.0
C3857 A0ININ 146  49.5477E-18 M=1.0
C3858 A7B3 167  58.6386E-18 M=1.0
C3859 A7B3 135  58.6386E-18 M=1.0
C3860 A7B3 102  58.6386E-18 M=1.0
C3861 A7B3 28  58.6386E-18 M=1.0
C3862 A7B3 25  58.6386E-18 M=1.0
C3863 A7B3 A0ININ  49.5477E-18 M=1.0
C3864 VD 28  55.3986E-18 M=1.0
C3865 28 166  52.3044E-18 M=1.0
C3866 28 165  52.3044E-18 M=1.0
C3867 28 164  52.3044E-18 M=1.0
C3868 28 166  49.5477E-18 M=1.0
C3869 28 165  49.5477E-18 M=1.0
C3870 28 164  49.5477E-18 M=1.0
C3871 166 167  58.6386E-18 M=1.0
C3872 165 167  58.6386E-18 M=1.0
C3873 164 167  58.6386E-18 M=1.0
C3874 135 166  58.6386E-18 M=1.0
C3875 135 165  58.6386E-18 M=1.0
C3876 135 164  58.6386E-18 M=1.0
C3877 102 166  58.6386E-18 M=1.0
C3878 102 165  58.6386E-18 M=1.0
C3879 102 164  58.6386E-18 M=1.0
C3880 25 166  49.5477E-18 M=1.0
C3881 25 165  49.5477E-18 M=1.0
C3882 25 164  49.5477E-18 M=1.0
C3883 GD 166  8.0137152E-15 M=1.0
C3884 GD 186  64.4274000000002E-18 M=1.0
C3885 GD 179  282.852E-18 M=1.0
C3886 VD 226  26.7137999999999E-18 M=1.0
C3887 VD 191  81.7128E-18 M=1.0
C3888 VD 186  33.7851E-18 M=1.0
C3889 VD 179  53.4276E-18 M=1.0
C3890 VD 173  40.0707E-18 M=1.0
C3891 VD 115  40.0707000000002E-18 M=1.0
C3892 115 186  75.2328E-18 M=1.0
C3893 GD 186  219.5424E-18 M=1.0
C3894 GD 115  136.2294E-18 M=1.0
C3895 VD 222  30.4272E-18 M=1.0
C3896 VD 221  30.4272E-18 M=1.0
C3897 VD 220  30.4272E-18 M=1.0
C3898 VD 186  67.8456E-18 M=1.0
C3899 VD 185  30.4272E-18 M=1.0
C3900 220 812  69.2001E-18 M=1.0
C3901 191 812  69.9552E-18 M=1.0
C3902 187 813  34.9776E-18 M=1.0
C3903 179 812  34.9776E-18 M=1.0
C3904 173 812  34.9776E-18 M=1.0
C3905 173 191  139.9104E-18 M=1.0
C3906 173 179  174.888E-18 M=1.0
C3907 103 813  34.9776E-18 M=1.0
C3908 GD 179  623.8467E-18 M=1.0
C3909 GD 115  6.4501524E-15 M=1.0
C3910 VD 813  65.9682E-18 M=1.0
C3911 VD 812  66.4299E-18 M=1.0
C3912 VD 191  689.1111E-18 M=1.0
C3913 191 812  104.2848E-18 M=1.0
C3914 191 423  52.3044E-18 M=1.0
C3915 191 358  52.3044E-18 M=1.0
C3916 191 354  52.3044E-18 M=1.0
C3917 191 226  25.6374E-18 M=1.0
C3918 191 222  28.0665E-18 M=1.0
C3919 179 812  99.25785E-18 M=1.0
C3920 179 220  53.565075E-18 M=1.0
C3921 179 191  103.5792E-18 M=1.0
C3922 173 220  51.406425E-18 M=1.0
C3923 173 191  103.5792E-18 M=1.0
C3924 28 812  52.3044E-18 M=1.0
C3925 28 358  52.3044E-18 M=1.0
C3926 28 354  104.6088E-18 M=1.0
C3927 28 191  327.6306E-18 M=1.0
C3928 GD 191  466.186275E-18 M=1.0
C3929 GD 185  174.5631E-18 M=1.0
C3930 VD 191  838.3041E-18 M=1.0
C3931 VD 28  570.325725E-18 M=1.0
C3932 186 191  109.89225E-18 M=1.0
C3933 185 191  43.8768E-18 M=1.0
C3934 185 186  64.755E-18 M=1.0
C3935 115 423  37.3761E-18 M=1.0
C3936 28 115  58.6386E-18 M=1.0
C3937 GD 167  282.852E-18 M=1.0
C3938 VD 167  53.4275999999999E-18 M=1.0
C3939 VD 102  53.4275999999998E-18 M=1.0
C3940 VD 25  81.7128000000001E-18 M=1.0
C3941 GD 177  44.0136E-18 M=1.0
C3942 VD 215  30.4272E-18 M=1.0
C3943 VD 208  30.4272E-18 M=1.0
C3944 VD 191  102.8232E-18 M=1.0
C3945 VD 178  30.4272E-18 M=1.0
C3946 VD 25  106.6266E-18 M=1.0
C3947 208 808  69.2001E-18 M=1.0
C3948 191 811  34.9776E-18 M=1.0
C3949 178 798  69.2001E-18 M=1.0
C3950 177 178  69.2001E-18 M=1.0
C3951 174 808  34.9776E-18 M=1.0
C3952 173 811  34.9776E-18 M=1.0
C3953 167 798  34.9776E-18 M=1.0
C3954 167 177  34.9776E-18 M=1.0
C3955 145 798  69.9552E-18 M=1.0
C3956 145 177  69.9552E-18 M=1.0
C3957 135 798  34.9776E-18 M=1.0
C3958 135 178  139.9104E-18 M=1.0
C3959 135 177  34.9776E-18 M=1.0
C3960 102 808  34.9776E-18 M=1.0
C3961 102 174  174.888E-18 M=1.0
C3962 25 808  69.9552E-18 M=1.0
C3963 GD 415  5.6979855E-15 M=1.0
C3964 GD 177  66.4299E-18 M=1.0
C3965 VD 811  65.9682E-18 M=1.0
C3966 VD 808  66.4299E-18 M=1.0
C3967 VD 798  66.4299E-18 M=1.0
C3968 VD 415  1.8946782E-15 M=1.0
C3969 VD 145  689.1111E-18 M=1.0
C3970 216 419  52.3044E-18 M=1.0
C3971 216 415  575.2332E-18 M=1.0
C3972 216 350  52.3044E-18 M=1.0
C3973 216 220  25.6374E-18 M=1.0
C3974 179 811  94.5387E-18 M=1.0
C3975 179 419  52.3044E-18 M=1.0
C3976 179 415  52.3044E-18 M=1.0
C3977 179 350  52.3044E-18 M=1.0
C3978 179 216  35.002575E-18 M=1.0
C3979 179 215  78.254775E-18 M=1.0
C3980 178 179  119.0898E-18 M=1.0
C3981 177 179  426.965625E-18 M=1.0
C3982 174 808  52.6203E-18 M=1.0
C3983 173 419  270.2394E-18 M=1.0
C3984 173 415  52.3044E-18 M=1.0
C3985 173 350  52.3044E-18 M=1.0
C3986 173 216  45.288225E-18 M=1.0
C3987 173 215  95.2119E-18 M=1.0
C3988 167 798  52.3044E-18 M=1.0
C3989 145 798  52.6203E-18 M=1.0
C3990 145 167  157.756725E-18 M=1.0
C3991 135 798  52.6203E-18 M=1.0
C3992 135 167  52.3044E-18 M=1.0
C3993 135 145  52.3044E-18 M=1.0
C3994 102 808  52.3044E-18 M=1.0
C3995 102 798  51.138E-18 M=1.0
C3996 102 174  52.3044E-18 M=1.0
C3997 102 167  28.3761E-18 M=1.0
C3998 25 808  52.6203E-18 M=1.0
C3999 25 415  52.3044E-18 M=1.0
C4000 25 350  164.3184E-18 M=1.0
C4001 25 174  52.3044E-18 M=1.0
C4002 25 102  104.6088E-18 M=1.0
C4003 GD 216  573.600825E-18 M=1.0
C4004 GD 174  214.1073E-18 M=1.0
C4005 GD 145  3.30096015E-15 M=1.0
C4006 GD 25  2.021975775E-15 M=1.0
C4007 VD 216  408.170025E-18 M=1.0
C4008 VD 174  1.1715003E-15 M=1.0
C4009 VD 145  354.0987E-18 M=1.0
C4010 VD 135  232.0479E-18 M=1.0
C4011 VD 102  774.42255E-18 M=1.0
C4012 VD 25  302.673825E-18 M=1.0
C4013 115 419  49.5477E-18 M=1.0
C4014 115 415  49.5477E-18 M=1.0
C4015 115 358  49.5477E-18 M=1.0
C4016 115 354  49.5477E-18 M=1.0
C4017 115 350  49.5477E-18 M=1.0
C4018 115 167  58.6386E-18 M=1.0
C4019 115 145  58.6386E-18 M=1.0
C4020 115 135  58.6386E-18 M=1.0
C4021 102 798  28.9818E-18 M=1.0
C4022 102 179  58.6386E-18 M=1.0
C4023 102 173  58.6386E-18 M=1.0
C4024 102 167  261.7938E-18 M=1.0
C4025 102 145  108.1863E-18 M=1.0
C4026 102 115  58.6386E-18 M=1.0
C4027 25 179  58.6386E-18 M=1.0
C4028 25 173  58.6386E-18 M=1.0
C4029 25 115  58.6386E-18 M=1.0
C4030 GD 102  328.7187E-18 M=1.0
C4031 GD 25  166.6368E-18 M=1.0
C4032 VD 102  82.29285E-18 M=1.0
C4033 GD 415  238.852800000001E-18 M=1.0
C4034 GD 358  188.568E-18 M=1.0
C4035 GD 342  188.568E-18 M=1.0
C4036 GD 155  31.82085E-18 M=1.0
C4037 GD 154  31.8208500000008E-18 M=1.0
C4038 GD 153  31.82085E-18 M=1.0
C4039 GD 152  31.8208500000008E-18 M=1.0
C4040 GD 151  31.8208499999999E-18 M=1.0
C4041 GD 150  31.8208500000001E-18 M=1.0
C4042 GD 149  31.8208499999999E-18 M=1.0
C4043 GD 148  31.8208499999982E-18 M=1.0
C4044 GD 122  31.82085E-18 M=1.0
C4045 GD 90  31.82085E-18 M=1.0
C4046 GD 38  282.852E-18 M=1.0
C4047 GD 14  31.82085E-18 M=1.0
C4048 GD 7  254.5668E-18 M=1.0
C4049 VD 415  113.1408E-18 M=1.0
C4050 VD 155  32.6065500000006E-18 M=1.0
C4051 VD 154  32.6065499999999E-18 M=1.0
C4052 VD 153  32.6065500000002E-18 M=1.0
C4053 VD 152  32.6065500000006E-18 M=1.0
C4054 VD 151  32.6065500000003E-18 M=1.0
C4055 VD 150  32.6065499999999E-18 M=1.0
C4056 VD 149  32.6065499999999E-18 M=1.0
C4057 VD 148  32.6065500000003E-18 M=1.0
C4058 362 415  75.2328E-18 M=1.0
C4059 358 415  75.2328E-18 M=1.0
C4060 354 415  75.2328E-18 M=1.0
C4061 350 415  75.2328E-18 M=1.0
C4062 346 415  75.2328E-18 M=1.0
C4063 346 411  75.2328E-18 M=1.0
C4064 346 407  75.2328E-18 M=1.0
C4065 346 403  75.2328E-18 M=1.0
C4066 342 415  75.2328E-18 M=1.0
C4067 338 415  75.2328E-18 M=1.0
C4068 155 415  75.2328E-18 M=1.0
C4069 154 415  75.2328E-18 M=1.0
C4070 153 415  75.2328E-18 M=1.0
C4071 152 415  75.2328E-18 M=1.0
C4072 151 415  75.2327999999999E-18 M=1.0
C4073 150 415  75.2327999999999E-18 M=1.0
C4074 149 415  75.2327999999999E-18 M=1.0
C4075 148 415  75.2327999999999E-18 M=1.0
C4076 GD 415  2.1642129E-15 M=1.0
C4077 GD 198  44.0136E-18 M=1.0
C4078 GD 155  78.5411999999999E-18 M=1.0
C4079 GD 154  78.5411999999999E-18 M=1.0
C4080 GD 153  78.5411999999999E-18 M=1.0
C4081 GD 152  78.5412000000002E-18 M=1.0
C4082 GD 151  78.5412E-18 M=1.0
C4083 GD 150  78.5411999999997E-18 M=1.0
C4084 GD 149  78.5412000000001E-18 M=1.0
C4085 GD 148  78.5412000000003E-18 M=1.0
C4086 GD 147  60.6455999999999E-18 M=1.0
C4087 GD 146  60.6455999999999E-18 M=1.0
C4088 GD 145  60.6456000000001E-18 M=1.0
C4089 GD 144  60.6456E-18 M=1.0
C4090 GD 143  60.6455999999999E-18 M=1.0
C4091 GD 142  60.6455999999999E-18 M=1.0
C4092 A0ININ 415  75.2328E-18 M=1.0
C4093 VD 155  56.0232E-18 M=1.0
C4094 VD 154  56.0232E-18 M=1.0
C4095 VD 153  56.0232000000002E-18 M=1.0
C4096 VD 152  56.0232E-18 M=1.0
C4097 VD 151  56.0232E-18 M=1.0
C4098 VD 150  56.0232E-18 M=1.0
C4099 VD 149  56.0232000000004E-18 M=1.0
C4100 VD 148  56.0231999999999E-18 M=1.0
C4101 VD 142  109.8144E-18 M=1.0
C4102 VD 141  34.2305999999999E-18 M=1.0
C4103 A7B3 GD  60.6456E-18 M=1.0
C4104 362 415  145.7748E-18 M=1.0
C4105 358 415  145.7748E-18 M=1.0
C4106 354 415  145.7748E-18 M=1.0
C4107 350 415  145.7748E-18 M=1.0
C4108 346 415  90.3761999999999E-18 M=1.0
C4109 342 415  90.3762E-18 M=1.0
C4110 338 415  90.3762E-18 M=1.0
C4111 155 338  100.9458E-18 M=1.0
C4112 154 342  100.9458E-18 M=1.0
C4113 153 346  100.9458E-18 M=1.0
C4114 152 350  100.9458E-18 M=1.0
C4115 151 354  100.9458E-18 M=1.0
C4116 150 358  100.9458E-18 M=1.0
C4117 149 362  100.9458E-18 M=1.0
C4118 147 342  65.5065E-18 M=1.0
C4119 146 346  65.5065000000001E-18 M=1.0
C4120 145 350  65.5065E-18 M=1.0
C4121 144 354  65.5065E-18 M=1.0
C4122 143 358  65.5065E-18 M=1.0
C4123 142 362  65.5065E-18 M=1.0
C4124 38 198  34.9776E-18 M=1.0
C4125 7 198  69.9552E-18 M=1.0
C4126 GD 407  4.9803174E-15 M=1.0
C4127 GD 346  22.80413565E-15 M=1.0
C4128 GD 198  66.4299000000001E-18 M=1.0
C4129 GD 142  6.29766899999999E-15 M=1.0
C4130 A0ININ 415  34.9776E-18 M=1.0
C4131 A0ININ 148  100.9458E-18 M=1.0
C4132 A0ININ 141  65.5065E-18 M=1.0
C4133 A7B3 338  65.5065E-18 M=1.0
C4134 279 407  52.3044E-18 M=1.0
C4135 278 407  52.3044E-18 M=1.0
C4136 198 279  52.3044E-18 M=1.0
C4137 198 278  52.3044E-18 M=1.0
C4138 142 407  37.6677E-18 M=1.0
C4139 142 403  52.3044E-18 M=1.0
C4140 142 147  52.3044E-18 M=1.0
C4141 142 146  52.3044E-18 M=1.0
C4142 142 145  52.3044E-18 M=1.0
C4143 142 144  52.3044E-18 M=1.0
C4144 142 143  52.3044E-18 M=1.0
C4145 141 407  37.6677E-18 M=1.0
C4146 141 403  52.3044E-18 M=1.0
C4147 141 147  52.3044E-18 M=1.0
C4148 141 146  52.3044E-18 M=1.0
C4149 141 145  52.3044E-18 M=1.0
C4150 141 144  52.3044E-18 M=1.0
C4151 141 143  52.3044E-18 M=1.0
C4152 141 142  52.3044000000001E-18 M=1.0
C4153 116 141  52.3044E-18 M=1.0
C4154 115 141  52.3044E-18 M=1.0
C4155 114 141  52.3044E-18 M=1.0
C4156 113 141  52.3044E-18 M=1.0
C4157 112 141  52.3044E-18 M=1.0
C4158 40 141  52.3044E-18 M=1.0
C4159 39 141  52.3044E-18 M=1.0
C4160 38 279  25.6374E-18 M=1.0
C4161 38 141  52.3044E-18 M=1.0
C4162 37 141  52.3044E-18 M=1.0
C4163 8 141  52.3044E-18 M=1.0
C4164 7 279  55.822725E-18 M=1.0
C4165 7 141  52.3044E-18 M=1.0
C4166 6 141  52.3044E-18 M=1.0
C4167 GD 279  312.932475E-18 M=1.0
C4168 GD 142  1.903752225E-15 M=1.0
C4169 GD 141  3.1844601E-15 M=1.0
C4170 GD 38  4.707560925E-15 M=1.0
C4171 A0ININ 142  52.3044E-18 M=1.0
C4172 A7B3 142  52.3044E-18 M=1.0
C4173 A7B3 141  52.3044E-18 M=1.0
C4174 407 415  37.3761E-18 M=1.0
C4175 403 415  49.5477E-18 M=1.0
C4176 362 415  129.49875E-18 M=1.0
C4177 358 415  125.2908E-18 M=1.0
C4178 354 415  125.264475E-18 M=1.0
C4179 350 415  142.1226E-18 M=1.0
C4180 346 415  129.49875E-18 M=1.0
C4181 342 415  137.91465E-18 M=1.0
C4182 338 415  142.1226E-18 M=1.0
C4183 166 407  40.54545E-18 M=1.0
C4184 165 407  40.54545E-18 M=1.0
C4185 164 407  40.54545E-18 M=1.0
C4186 147 415  68.23575E-18 M=1.0
C4187 147 407  40.54545E-18 M=1.0
C4188 146 415  49.5477E-18 M=1.0
C4189 146 407  40.54545E-18 M=1.0
C4190 145 415  65.0664E-18 M=1.0
C4191 145 407  40.54545E-18 M=1.0
C4192 144 415  49.5477E-18 M=1.0
C4193 143 415  49.5477E-18 M=1.0
C4194 142 415  41.1318E-18 M=1.0
C4195 134 407  40.54545E-18 M=1.0
C4196 133 407  40.54545E-18 M=1.0
C4197 116 407  40.54545E-18 M=1.0
C4198 115 407  40.54545E-18 M=1.0
C4199 114 407  75.963825E-18 M=1.0
C4200 101 407  40.54545E-18 M=1.0
C4201 39 407  49.5477E-18 M=1.0
C4202 8 407  49.5477E-18 M=1.0
C4203 GD 415  3.3968448E-15 M=1.0
C4204 GD 8  3.0744189E-15 M=1.0
C4205 A0ININ 415  125.264475E-18 M=1.0
C4206 VD 415  1.0290168E-15 M=1.0
C4207 VD 411  1.0252944E-15 M=1.0
C4208 VD 114  782.5014E-18 M=1.0
C4209 VD 39  40.54545E-18 M=1.0
C4210 A7B3 407  40.54545E-18 M=1.0
C4211 GD 403  238.852800000001E-18 M=1.0
C4212 GD 124  31.82085E-18 M=1.0
C4213 GD 123  31.8208500000008E-18 M=1.0
C4214 GD 92  31.82085E-18 M=1.0
C4215 GD 91  31.8208500000008E-18 M=1.0
C4216 GD 16  31.82085E-18 M=1.0
C4217 GD 15  31.8208500000008E-18 M=1.0
C4218 VD 411  113.1408E-18 M=1.0
C4219 VD 403  113.1408E-18 M=1.0
C4220 VD 342  295.423199999999E-18 M=1.0
C4221 VD 124  32.6065500000006E-18 M=1.0
C4222 VD 123  32.6065499999999E-18 M=1.0
C4223 VD 122  32.6065500000002E-18 M=1.0
C4224 VD 92  32.6065500000006E-18 M=1.0
C4225 VD 91  32.6065499999999E-18 M=1.0
C4226 VD 90  32.6065500000002E-18 M=1.0
C4227 VD 16  32.6065500000006E-18 M=1.0
C4228 VD 15  32.6065499999999E-18 M=1.0
C4229 VD 14  32.6065500000002E-18 M=1.0
C4230 342 411  75.2328E-18 M=1.0
C4231 342 407  75.2328E-18 M=1.0
C4232 342 403  75.2328E-18 M=1.0
C4233 338 411  75.2328E-18 M=1.0
C4234 338 407  75.2328E-18 M=1.0
C4235 338 403  75.2328E-18 M=1.0
C4236 124 411  75.2328E-18 M=1.0
C4237 123 411  75.2328E-18 M=1.0
C4238 122 411  75.2328E-18 M=1.0
C4239 92 407  75.2328E-18 M=1.0
C4240 91 407  75.2328E-18 M=1.0
C4241 90 407  75.2328E-18 M=1.0
C4242 16 403  75.2328E-18 M=1.0
C4243 15 403  75.2328E-18 M=1.0
C4244 14 403  75.2328E-18 M=1.0
C4245 GD 411  3.0218796E-15 M=1.0
C4246 GD 407  4.24133190000001E-15 M=1.0
C4247 GD 342  316.703699999999E-18 M=1.0
C4248 GD 338  316.7037E-18 M=1.0
C4249 GD 124  78.5411999999999E-18 M=1.0
C4250 GD 123  78.5411999999999E-18 M=1.0
C4251 GD 122  78.5411999999999E-18 M=1.0
C4252 GD 92  78.5411999999999E-18 M=1.0
C4253 GD 91  78.5411999999999E-18 M=1.0
C4254 GD 90  78.5411999999999E-18 M=1.0
C4255 GD 40  60.6456E-18 M=1.0
C4256 GD 38  133.0416E-18 M=1.0
C4257 GD 16  78.5411999999999E-18 M=1.0
C4258 GD 15  78.5411999999999E-18 M=1.0
C4259 GD 14  78.5411999999999E-18 M=1.0
C4260 GD 8  60.6456E-18 M=1.0
C4261 GD 7  60.6455999999999E-18 M=1.0
C4262 GD 6  60.6455999999999E-18 M=1.0
C4263 VD 342  193.730399999999E-18 M=1.0
C4264 VD 124  56.0232E-18 M=1.0
C4265 VD 123  56.0232E-18 M=1.0
C4266 VD 122  56.0232000000002E-18 M=1.0
C4267 VD 116  34.2306E-18 M=1.0
C4268 VD 115  34.2306E-18 M=1.0
C4269 VD 114  34.2306E-18 M=1.0
C4270 VD 92  56.0232E-18 M=1.0
C4271 VD 91  56.0232E-18 M=1.0
C4272 VD 90  56.0232000000002E-18 M=1.0
C4273 VD 39  34.2306E-18 M=1.0
C4274 VD 38  34.2306E-18 M=1.0
C4275 VD 16  56.0232E-18 M=1.0
C4276 VD 15  56.0232E-18 M=1.0
C4277 VD 14  56.0232000000002E-18 M=1.0
C4278 VD 7  106.6266E-18 M=1.0
C4279 346 411  145.7748E-18 M=1.0
C4280 346 407  34.9776E-18 M=1.0
C4281 346 403  34.9776E-18 M=1.0
C4282 342 411  90.3762E-18 M=1.0
C4283 342 407  34.9776E-18 M=1.0
C4284 342 403  34.9776E-18 M=1.0
C4285 338 411  90.3762E-18 M=1.0
C4286 338 407  95.1993E-18 M=1.0
C4287 338 403  34.9776E-18 M=1.0
C4288 124 338  100.9458E-18 M=1.0
C4289 123 342  100.9458E-18 M=1.0
C4290 122 346  100.9458E-18 M=1.0
C4291 116 338  65.5065E-18 M=1.0
C4292 115 342  65.5065E-18 M=1.0
C4293 114 346  65.5065000000001E-18 M=1.0
C4294 92 338  100.9458E-18 M=1.0
C4295 91 342  100.9458E-18 M=1.0
C4296 90 346  100.9458E-18 M=1.0
C4297 40 338  65.5065E-18 M=1.0
C4298 39 342  65.5065E-18 M=1.0
C4299 38 346  65.5065000000001E-18 M=1.0
C4300 16 338  100.9458E-18 M=1.0
C4301 15 342  100.9458E-18 M=1.0
C4302 14 346  100.9458E-18 M=1.0
C4303 8 338  65.5065E-18 M=1.0
C4304 7 342  65.5065E-18 M=1.0
C4305 6 346  65.5065000000001E-18 M=1.0
C4306 GD 350  23.9328936E-15 M=1.0
C4307 354 358  104.6088E-18 M=1.0
C4308 350 362  104.6088E-18 M=1.0
C4309 342 362  104.6088E-18 M=1.0
C4310 342 350  104.6088E-18 M=1.0
C4311 338 346  104.6088E-18 M=1.0
C4312 338 342  104.6088E-18 M=1.0
C4313 147 346  52.3044E-18 M=1.0
C4314 116 346  52.3044E-18 M=1.0
C4315 116 342  52.3044E-18 M=1.0
C4316 115 346  52.3044E-18 M=1.0
C4317 40 346  52.3044E-18 M=1.0
C4318 40 342  52.3044E-18 M=1.0
C4319 39 346  52.3044E-18 M=1.0
C4320 8 346  52.3044E-18 M=1.0
C4321 8 342  52.3044E-18 M=1.0
C4322 7 346  52.3044E-18 M=1.0
C4323 GD 362  1.72971045E-15 M=1.0
C4324 GD 358  2.31120855E-15 M=1.0
C4325 GD 342  4.5632817E-15 M=1.0
C4326 GD 116  7.21288395E-15 M=1.0
C4327 GD 8  6.13206765E-15 M=1.0
C4328 A0ININ 362  104.6088E-18 M=1.0
C4329 A0ININ 346  104.6088E-18 M=1.0
C4330 VD 40  346.08015E-18 M=1.0
C4331 VD 39  289.1745E-18 M=1.0
C4332 A7B3 346  52.3044E-18 M=1.0
C4333 A7B3 342  52.3044E-18 M=1.0
C4334 346 411  129.49875E-18 M=1.0
C4335 346 407  129.49875E-18 M=1.0
C4336 346 403  129.49875E-18 M=1.0
C4337 342 411  137.91465E-18 M=1.0
C4338 342 407  137.91465E-18 M=1.0
C4339 342 403  137.91465E-18 M=1.0
C4340 338 411  142.1226E-18 M=1.0
C4341 338 407  142.1226E-18 M=1.0
C4342 338 403  142.1226E-18 M=1.0
C4343 GD 411  2.464902E-15 M=1.0
C4344 GD 407  238.852800000001E-18 M=1.0
C4345 GD 350  188.568E-18 M=1.0
C4346 GD 89  31.8208500000008E-18 M=1.0
C4347 GD 44  31.8208499999999E-18 M=1.0
C4348 GD 43  31.8208500000001E-18 M=1.0
C4349 GD 42  31.8208499999999E-18 M=1.0
C4350 GD 41  31.8208499999982E-18 M=1.0
C4351 VD 407  113.1408E-18 M=1.0
C4352 VD 350  295.423199999998E-18 M=1.0
C4353 VD 89  32.6065500000006E-18 M=1.0
C4354 VD 44  32.6065500000003E-18 M=1.0
C4355 VD 43  32.6065499999999E-18 M=1.0
C4356 VD 42  32.6065499999999E-18 M=1.0
C4357 VD 41  32.6065500000003E-18 M=1.0
C4358 362 407  75.2328E-18 M=1.0
C4359 358 407  75.2328E-18 M=1.0
C4360 354 407  75.2328E-18 M=1.0
C4361 350 407  75.2328E-18 M=1.0
C4362 89 407  75.2328E-18 M=1.0
C4363 44 407  75.2327999999999E-18 M=1.0
C4364 43 407  75.2327999999999E-18 M=1.0
C4365 42 407  75.2327999999999E-18 M=1.0
C4366 41 407  75.2327999999999E-18 M=1.0
C4367 GD 89  78.5412000000002E-18 M=1.0
C4368 GD 44  78.5412E-18 M=1.0
C4369 GD 43  78.5411999999998E-18 M=1.0
C4370 GD 42  78.5412000000001E-18 M=1.0
C4371 GD 41  78.5412000000003E-18 M=1.0
C4372 A0ININ 407  75.2328E-18 M=1.0
C4373 VD 362  193.7304E-18 M=1.0
C4374 VD 354  193.7304E-18 M=1.0
C4375 VD 89  56.0232E-18 M=1.0
C4376 VD 44  56.0232E-18 M=1.0
C4377 VD 43  56.0232E-18 M=1.0
C4378 VD 42  56.0232000000004E-18 M=1.0
C4379 VD 41  56.0231999999999E-18 M=1.0
C4380 VD 37  34.2306E-18 M=1.0
C4381 VD 36  34.2306000000001E-18 M=1.0
C4382 VD 35  34.2306000000001E-18 M=1.0
C4383 VD 34  34.2306E-18 M=1.0
C4384 VD 33  34.2305999999999E-18 M=1.0
C4385 362 407  34.9776E-18 M=1.0
C4386 358 407  34.9776E-18 M=1.0
C4387 354 407  34.9776E-18 M=1.0
C4388 350 407  34.9776E-18 M=1.0
C4389 89 350  100.9458E-18 M=1.0
C4390 44 354  100.9458E-18 M=1.0
C4391 43 358  100.9458E-18 M=1.0
C4392 42 362  100.9458E-18 M=1.0
C4393 37 350  65.5065E-18 M=1.0
C4394 36 354  65.5065E-18 M=1.0
C4395 35 358  65.5065E-18 M=1.0
C4396 34 362  65.5065E-18 M=1.0
C4397 GD 403  15.34825395E-15 M=1.0
C4398 GD 147  4.2311628E-15 M=1.0
C4399 GD 146  4.2311628E-15 M=1.0
C4400 GD 36  11.9633904E-15 M=1.0
C4401 A0ININ 407  34.9776E-18 M=1.0
C4402 A0ININ 41  100.9458E-18 M=1.0
C4403 A0ININ 33  65.5065E-18 M=1.0
C4404 VD 362  3.7467189E-15 M=1.0
C4405 147 403  52.3044E-18 M=1.0
C4406 146 403  52.3044E-18 M=1.0
C4407 146 147  225.8919E-18 M=1.0
C4408 145 403  52.3044E-18 M=1.0
C4409 145 147  52.3044E-18 M=1.0
C4410 145 146  52.3044E-18 M=1.0
C4411 144 403  52.3044E-18 M=1.0
C4412 144 147  52.3044E-18 M=1.0
C4413 144 146  52.3044E-18 M=1.0
C4414 143 403  52.3044E-18 M=1.0
C4415 143 147  52.3044E-18 M=1.0
C4416 143 146  52.3044E-18 M=1.0
C4417 116 407  37.6677E-18 M=1.0
C4418 116 403  52.3044E-18 M=1.0
C4419 116 362  52.3044E-18 M=1.0
C4420 116 358  52.3044E-18 M=1.0
C4421 116 354  52.3044E-18 M=1.0
C4422 116 350  52.3044E-18 M=1.0
C4423 115 403  52.3044E-18 M=1.0
C4424 114 403  52.3044E-18 M=1.0
C4425 113 403  52.3044E-18 M=1.0
C4426 112 403  52.3044E-18 M=1.0
C4427 111 403  52.3044E-18 M=1.0
C4428 110 403  52.3044E-18 M=1.0
C4429 109 403  52.3044E-18 M=1.0
C4430 40 403  52.3044E-18 M=1.0
C4431 39 403  52.3044E-18 M=1.0
C4432 38 403  52.3044E-18 M=1.0
C4433 37 403  52.3044E-18 M=1.0
C4434 36 403  52.3044E-18 M=1.0
C4435 36 362  52.3044E-18 M=1.0
C4436 36 358  52.3044E-18 M=1.0
C4437 36 40  52.3044E-18 M=1.0
C4438 36 39  52.3044E-18 M=1.0
C4439 36 38  52.3044E-18 M=1.0
C4440 36 37  52.3044E-18 M=1.0
C4441 35 403  52.3044E-18 M=1.0
C4442 35 362  52.3044E-18 M=1.0
C4443 35 40  52.3044E-18 M=1.0
C4444 35 39  52.3044E-18 M=1.0
C4445 35 38  52.3044E-18 M=1.0
C4446 35 37  52.3044E-18 M=1.0
C4447 35 36  52.3044E-18 M=1.0
C4448 34 403  52.3044E-18 M=1.0
C4449 34 40  52.3044E-18 M=1.0
C4450 34 39  52.3044E-18 M=1.0
C4451 34 38  52.3044E-18 M=1.0
C4452 34 37  52.3044E-18 M=1.0
C4453 34 36  52.3044E-18 M=1.0
C4454 34 35  52.3044E-18 M=1.0
C4455 33 403  52.3044E-18 M=1.0
C4456 33 40  52.3044E-18 M=1.0
C4457 33 39  52.3044E-18 M=1.0
C4458 33 38  52.3044E-18 M=1.0
C4459 33 37  52.3044E-18 M=1.0
C4460 33 36  52.3044E-18 M=1.0
C4461 33 35  52.3044E-18 M=1.0
C4462 33 34  52.3044E-18 M=1.0
C4463 8 36  52.3044E-18 M=1.0
C4464 8 35  52.3044E-18 M=1.0
C4465 8 34  52.3044E-18 M=1.0
C4466 8 33  52.3044E-18 M=1.0
C4467 7 36  52.3044E-18 M=1.0
C4468 7 35  52.3044E-18 M=1.0
C4469 7 34  52.3044E-18 M=1.0
C4470 7 33  52.3044E-18 M=1.0
C4471 6 36  52.3044E-18 M=1.0
C4472 6 35  52.3044E-18 M=1.0
C4473 6 34  52.3044E-18 M=1.0
C4474 6 33  52.3044E-18 M=1.0
C4475 GD 110  3.465485775E-15 M=1.0
C4476 GD 36  5.0302494E-15 M=1.0
C4477 GD 35  4.6619352E-15 M=1.0
C4478 GD 34  4.330685925E-15 M=1.0
C4479 GD 33  3.78171405E-15 M=1.0
C4480 A0ININ 116  52.3044E-18 M=1.0
C4481 A0ININ 36  52.3044E-18 M=1.0
C4482 A0ININ 35  52.3044E-18 M=1.0
C4483 A0ININ 34  52.3044E-18 M=1.0
C4484 VD 37  213.8391E-18 M=1.0
C4485 A7B3 403  52.3044E-18 M=1.0
C4486 A7B3 147  52.3044E-18 M=1.0
C4487 A7B3 146  52.3044E-18 M=1.0
C4488 A7B3 145  52.3044E-18 M=1.0
C4489 A7B3 144  52.3044E-18 M=1.0
C4490 A7B3 143  52.3044E-18 M=1.0
C4491 403 411  49.5477E-18 M=1.0
C4492 362 407  129.49875E-18 M=1.0
C4493 358 407  125.2908E-18 M=1.0
C4494 354 407  125.2908E-18 M=1.0
C4495 350 407  142.1226E-18 M=1.0
C4496 GD 407  1.9422684E-15 M=1.0
C4497 A0ININ 407  125.2908E-18 M=1.0
C4498 VD 407  1.0252944E-15 M=1.0
C4499 GD 362  188.568E-18 M=1.0
C4500 GD 354  188.568E-18 M=1.0
C4501 GD 13  31.8208500000008E-18 M=1.0
C4502 GD 12  31.8208499999999E-18 M=1.0
C4503 GD 11  31.8208500000001E-18 M=1.0
C4504 GD 10  31.8208499999999E-18 M=1.0
C4505 GD 9  31.8208499999982E-18 M=1.0
C4506 VD 13  32.6065500000006E-18 M=1.0
C4507 VD 12  32.6065500000003E-18 M=1.0
C4508 VD 11  32.6065499999999E-18 M=1.0
C4509 VD 10  32.6065499999999E-18 M=1.0
C4510 VD 9  32.6065500000003E-18 M=1.0
C4511 362 403  75.2328E-18 M=1.0
C4512 358 403  75.2328E-18 M=1.0
C4513 354 403  75.2328E-18 M=1.0
C4514 350 403  75.2328E-18 M=1.0
C4515 13 403  75.2328E-18 M=1.0
C4516 12 403  75.2327999999999E-18 M=1.0
C4517 11 403  75.2327999999999E-18 M=1.0
C4518 10 403  75.2327999999999E-18 M=1.0
C4519 9 403  75.2327999999999E-18 M=1.0
C4520 GD 403  791.493299999999E-18 M=1.0
C4521 GD 13  78.5412000000002E-18 M=1.0
C4522 GD 12  78.5412E-18 M=1.0
C4523 GD 11  78.5411999999997E-18 M=1.0
C4524 GD 10  78.5412000000001E-18 M=1.0
C4525 GD 9  78.5412000000003E-18 M=1.0
C4526 GD 5  60.6456000000001E-18 M=1.0
C4527 GD 4  60.6456E-18 M=1.0
C4528 GD 3  60.6455999999999E-18 M=1.0
C4529 GD 2  60.6455999999999E-18 M=1.0
C4530 A0ININ 403  75.2328E-18 M=1.0
C4531 VD 350  193.7304E-18 M=1.0
C4532 VD 13  56.0232E-18 M=1.0
C4533 VD 12  56.0232E-18 M=1.0
C4534 VD 11  56.0232E-18 M=1.0
C4535 VD 10  56.0232000000004E-18 M=1.0
C4536 VD 9  56.0231999999999E-18 M=1.0
C4537 VD 4  106.6266E-18 M=1.0
C4538 VD 2  109.8144E-18 M=1.0
C4539 VD 1  54.6435000000002E-18 M=1.0
C4540 362 403  34.9776E-18 M=1.0
C4541 358 403  34.9776E-18 M=1.0
C4542 354 403  34.9776E-18 M=1.0
C4543 350 403  34.9776E-18 M=1.0
C4544 13 350  100.9458E-18 M=1.0
C4545 12 354  100.9458E-18 M=1.0
C4546 11 358  100.9458E-18 M=1.0
C4547 10 362  100.9458E-18 M=1.0
C4548 5 350  65.5065E-18 M=1.0
C4549 4 354  65.5065E-18 M=1.0
C4550 3 358  65.5065E-18 M=1.0
C4551 2 362  65.5065E-18 M=1.0
C4552 GD 1500  108.045E-18 M=1.0
C4553 GD 362  32.732109E-15 M=1.0
C4554 A0ININ 403  34.9776E-18 M=1.0
C4555 A0ININ 9  100.9458E-18 M=1.0
C4556 A0ININ 1  65.5065E-18 M=1.0
C4557 VD 358  3.6260559E-15 M=1.0
C4558 VD 350  4.5017028E-15 M=1.0
C4559 VD A0ININ  4.3331742E-15 M=1.0
C4560 40 362  52.3044E-18 M=1.0
C4561 40 358  52.3044E-18 M=1.0
C4562 40 354  52.3044E-18 M=1.0
C4563 40 350  52.3044E-18 M=1.0
C4564 39 362  52.3044E-18 M=1.0
C4565 39 358  52.3044E-18 M=1.0
C4566 39 354  52.3044E-18 M=1.0
C4567 39 350  52.3044E-18 M=1.0
C4568 38 362  52.3044E-18 M=1.0
C4569 38 358  52.3044E-18 M=1.0
C4570 38 354  52.3044E-18 M=1.0
C4571 38 350  52.3044E-18 M=1.0
C4572 37 362  52.3044E-18 M=1.0
C4573 37 358  52.3044E-18 M=1.0
C4574 37 354  52.3044E-18 M=1.0
C4575 8 362  52.3044E-18 M=1.0
C4576 8 358  52.3044E-18 M=1.0
C4577 8 354  52.3044E-18 M=1.0
C4578 8 350  52.3044E-18 M=1.0
C4579 7 1500  60.876E-18 M=1.0
C4580 7 362  52.3044E-18 M=1.0
C4581 7 358  52.3044E-18 M=1.0
C4582 7 354  52.3044E-18 M=1.0
C4583 7 350  52.3044E-18 M=1.0
C4584 6 362  52.3044E-18 M=1.0
C4585 6 358  52.3044E-18 M=1.0
C4586 6 354  52.3044E-18 M=1.0
C4587 6 350  52.3044E-18 M=1.0
C4588 5 362  52.3044E-18 M=1.0
C4589 5 358  52.3044E-18 M=1.0
C4590 5 354  52.3044E-18 M=1.0
C4591 4 362  52.3044E-18 M=1.0
C4592 4 358  52.3044E-18 M=1.0
C4593 3 362  52.3044E-18 M=1.0
C4594 GD 40  6.08882805E-15 M=1.0
C4595 GD 37  4.01588145E-15 M=1.0
C4596 GD 7  6.00860025E-15 M=1.0
C4597 GD 3  5.840505E-15 M=1.0
C4598 A0ININ 40  52.3044E-18 M=1.0
C4599 A0ININ 39  52.3044E-18 M=1.0
C4600 A0ININ 38  52.3044E-18 M=1.0
C4601 A0ININ 37  52.3044E-18 M=1.0
C4602 A0ININ 8  52.3044E-18 M=1.0
C4603 A0ININ 7  52.3044E-18 M=1.0
C4604 A0ININ 6  52.3044E-18 M=1.0
C4605 A0ININ 5  52.3044E-18 M=1.0
C4606 A0ININ 4  52.3044E-18 M=1.0
C4607 A0ININ 3  52.3044E-18 M=1.0
C4608 A0ININ 2  52.3044E-18 M=1.0
C4609 VD 2  258.306525E-18 M=1.0
C4610 362 403  129.49875E-18 M=1.0
C4611 358 403  125.2908E-18 M=1.0
C4612 354 403  125.2908E-18 M=1.0
C4613 350 403  142.1226E-18 M=1.0
C4614 GD 403  2.010438E-15 M=1.0
C4615 A0ININ 403  125.2908E-18 M=1.0
C4616 VD 403  1.0252944E-15 M=1.0
C4617 GD 40  8.94107699999999E-15 M=1.0
C4618 GD 8  9.2184507E-15 M=1.0
C4619 GD 7  9.1912572E-15 M=1.0
C4620 GD 6  9.1858185E-15 M=1.0
C4621 GD 5  12.6557091E-15 M=1.0
C4622 GD 4  14.4939897E-15 M=1.0
C4623 GD 3  16.3594638E-15 M=1.0
C4624 GD 2  18.1651122E-15 M=1.0
C4625 GD 1  19.7477739E-15 M=1.0
C4626 39 40  52.3044E-18 M=1.0
C4627 38 40  52.3044E-18 M=1.0
C4628 38 39  52.3044E-18 M=1.0
C4629 37 40  52.3044E-18 M=1.0
C4630 37 39  52.3044E-18 M=1.0
C4631 37 38  52.3044E-18 M=1.0
C4632 7 8  52.3044E-18 M=1.0
C4633 6 8  52.3044E-18 M=1.0
C4634 6 7  52.3044E-18 M=1.0
C4635 5 8  52.3044E-18 M=1.0
C4636 5 7  52.3044E-18 M=1.0
C4637 5 6  52.3044E-18 M=1.0
C4638 4 8  52.3044E-18 M=1.0
C4639 4 7  52.3044E-18 M=1.0
C4640 4 6  52.3044E-18 M=1.0
C4641 4 5  52.3044E-18 M=1.0
C4642 3 8  52.3044E-18 M=1.0
C4643 3 7  52.3044E-18 M=1.0
C4644 3 6  52.3044E-18 M=1.0
C4645 3 5  52.3044E-18 M=1.0
C4646 3 4  52.3044E-18 M=1.0
C4647 2 8  52.3044E-18 M=1.0
C4648 2 7  52.3044E-18 M=1.0
C4649 2 6  52.3044E-18 M=1.0
C4650 2 5  52.3044E-18 M=1.0
C4651 2 4  52.3044E-18 M=1.0
C4652 2 3  52.3043999999999E-18 M=1.0
C4653 1 8  52.3044E-18 M=1.0
C4654 1 7  52.3044E-18 M=1.0
C4655 1 6  52.3044E-18 M=1.0
C4656 1 5  52.3044E-18 M=1.0
C4657 1 4  52.3044E-18 M=1.0
C4658 1 3  52.3043999999999E-18 M=1.0
C4659 1 2  52.3044000000001E-18 M=1.0
C4660 GD 2  5.514183675E-15 M=1.0
C4661 GD 1  5.6942325E-15 M=1.0
C4662 GD 411  238.852800000001E-18 M=1.0
C4663 GD 121  31.8208500000008E-18 M=1.0
C4664 GD 120  31.8208499999999E-18 M=1.0
C4665 GD 119  31.8208500000001E-18 M=1.0
C4666 GD 118  31.8208499999999E-18 M=1.0
C4667 GD 117  31.8208499999982E-18 M=1.0
C4668 A0ININ GD  188.568E-18 M=1.0
C4669 VD 121  32.6065500000006E-18 M=1.0
C4670 VD 120  32.6065500000003E-18 M=1.0
C4671 VD 119  32.6065499999999E-18 M=1.0
C4672 VD 118  32.6065499999999E-18 M=1.0
C4673 VD 117  32.6065500000003E-18 M=1.0
C4674 362 411  75.2328E-18 M=1.0
C4675 358 411  75.2328E-18 M=1.0
C4676 354 411  75.2328E-18 M=1.0
C4677 350 411  75.2328E-18 M=1.0
C4678 121 411  75.2328E-18 M=1.0
C4679 120 411  75.2327999999999E-18 M=1.0
C4680 119 411  75.2327999999999E-18 M=1.0
C4681 118 411  75.2327999999999E-18 M=1.0
C4682 117 411  75.2327999999999E-18 M=1.0
C4683 GD 362  316.7037E-18 M=1.0
C4684 GD 121  78.5412000000002E-18 M=1.0
C4685 GD 120  78.5412E-18 M=1.0
C4686 GD 119  78.5411999999997E-18 M=1.0
C4687 GD 118  78.5412000000001E-18 M=1.0
C4688 GD 117  78.5412000000003E-18 M=1.0
C4689 GD 112  136.2294E-18 M=1.0
C4690 GD 109  136.2294E-18 M=1.0
C4691 A0ININ 411  75.2328E-18 M=1.0
C4692 VD 121  56.0232E-18 M=1.0
C4693 VD 120  56.0232E-18 M=1.0
C4694 VD 119  56.0232E-18 M=1.0
C4695 VD 118  56.0232000000004E-18 M=1.0
C4696 VD 117  56.0231999999999E-18 M=1.0
C4697 VD 113  34.2306E-18 M=1.0
C4698 VD 112  34.2306000000001E-18 M=1.0
C4699 VD 111  34.2306000000001E-18 M=1.0
C4700 VD 110  34.2306E-18 M=1.0
C4701 VD 109  34.2305999999999E-18 M=1.0
C4702 VD A0ININ  193.7304E-18 M=1.0
C4703 362 411  34.9776E-18 M=1.0
C4704 358 411  145.7748E-18 M=1.0
C4705 354 411  145.7748E-18 M=1.0
C4706 350 411  145.7748E-18 M=1.0
C4707 121 350  100.9458E-18 M=1.0
C4708 120 354  100.9458E-18 M=1.0
C4709 119 358  100.9458E-18 M=1.0
C4710 118 362  100.9458E-18 M=1.0
C4711 113 350  65.5065E-18 M=1.0
C4712 112 354  65.5065E-18 M=1.0
C4713 111 358  65.5065E-18 M=1.0
C4714 110 362  65.5065E-18 M=1.0
C4715 A0ININ 411  34.9776E-18 M=1.0
C4716 A0ININ 117  100.9458E-18 M=1.0
C4717 A0ININ 109  65.5065E-18 M=1.0
C4718 147 407  37.6677E-18 M=1.0
C4719 147 362  52.3044E-18 M=1.0
C4720 147 358  52.3044E-18 M=1.0
C4721 147 354  52.3044E-18 M=1.0
C4722 147 350  52.3044E-18 M=1.0
C4723 146 407  37.6677E-18 M=1.0
C4724 146 362  52.3044E-18 M=1.0
C4725 146 358  52.3044E-18 M=1.0
C4726 146 354  52.3044E-18 M=1.0
C4727 146 350  52.3044E-18 M=1.0
C4728 145 407  37.6677E-18 M=1.0
C4729 145 362  52.3044E-18 M=1.0
C4730 145 358  52.3044E-18 M=1.0
C4731 145 354  52.3044E-18 M=1.0
C4732 144 407  37.6677E-18 M=1.0
C4733 144 362  52.3044E-18 M=1.0
C4734 144 358  52.3044E-18 M=1.0
C4735 143 407  37.6677E-18 M=1.0
C4736 143 362  52.3044E-18 M=1.0
C4737 115 407  37.6677E-18 M=1.0
C4738 115 362  52.3044E-18 M=1.0
C4739 115 358  52.3044E-18 M=1.0
C4740 115 354  52.3044E-18 M=1.0
C4741 115 350  52.3044E-18 M=1.0
C4742 114 407  37.6677E-18 M=1.0
C4743 114 362  52.3044E-18 M=1.0
C4744 114 358  52.3044E-18 M=1.0
C4745 114 354  52.3044E-18 M=1.0
C4746 114 350  52.3044E-18 M=1.0
C4747 113 407  37.6677E-18 M=1.0
C4748 113 362  52.3044E-18 M=1.0
C4749 113 358  52.3044E-18 M=1.0
C4750 113 354  52.3044E-18 M=1.0
C4751 112 407  37.6677E-18 M=1.0
C4752 112 362  52.3044E-18 M=1.0
C4753 112 358  52.3044E-18 M=1.0
C4754 111 407  37.6677E-18 M=1.0
C4755 111 362  52.3044E-18 M=1.0
C4756 110 407  37.6677E-18 M=1.0
C4757 109 407  37.6677E-18 M=1.0
C4758 GD 146  3.981198825E-15 M=1.0
C4759 GD 144  3.52431585E-15 M=1.0
C4760 GD 115  4.7783736E-15 M=1.0
C4761 GD 114  4.190028525E-15 M=1.0
C4762 A0ININ 146  104.6088E-18 M=1.0
C4763 A0ININ 145  52.3044E-18 M=1.0
C4764 A0ININ 144  52.3044E-18 M=1.0
C4765 A0ININ 143  52.3044E-18 M=1.0
C4766 A0ININ 115  52.3044E-18 M=1.0
C4767 A0ININ 114  52.3044E-18 M=1.0
C4768 A0ININ 113  52.3044E-18 M=1.0
C4769 A0ININ 112  52.3044E-18 M=1.0
C4770 A0ININ 111  52.3044E-18 M=1.0
C4771 A0ININ 110  52.3044E-18 M=1.0
C4772 VD 112  340.1757E-18 M=1.0
C4773 VD 111  276.273E-18 M=1.0
C4774 A7B3 407  37.6677E-18 M=1.0
C4775 A7B3 362  52.3044E-18 M=1.0
C4776 A7B3 358  52.3044E-18 M=1.0
C4777 A7B3 354  52.3044E-18 M=1.0
C4778 A7B3 350  52.3044E-18 M=1.0
C4779 A7B3 GD  5.22734355E-15 M=1.0
C4780 A7B3 A0ININ  52.3044E-18 M=1.0
C4781 407 411  37.3761E-18 M=1.0
C4782 362 411  129.49875E-18 M=1.0
C4783 358 411  125.2908E-18 M=1.0
C4784 354 411  125.2908E-18 M=1.0
C4785 350 411  142.1226E-18 M=1.0
C4786 A0ININ 411  125.2908E-18 M=1.0
C4787 GD 145  4.2257241E-15 M=1.0
C4788 GD 144  4.2202854E-15 M=1.0
C4789 GD 143  5.1611805E-15 M=1.0
C4790 GD 110  12.095523E-15 M=1.0
C4791 144 145  52.3044E-18 M=1.0
C4792 143 145  52.3044E-18 M=1.0
C4793 143 144  52.3044E-18 M=1.0
C4794 115 116  52.3044E-18 M=1.0
C4795 114 116  52.3044E-18 M=1.0
C4796 114 115  52.3044E-18 M=1.0
C4797 113 116  52.3044E-18 M=1.0
C4798 113 115  52.3044E-18 M=1.0
C4799 113 114  52.3044E-18 M=1.0
C4800 112 116  52.3044E-18 M=1.0
C4801 112 115  52.3044E-18 M=1.0
C4802 112 114  52.3044E-18 M=1.0
C4803 112 113  52.3044E-18 M=1.0
C4804 111 116  52.3044E-18 M=1.0
C4805 111 115  52.3044E-18 M=1.0
C4806 111 114  52.3044E-18 M=1.0
C4807 111 113  52.3044E-18 M=1.0
C4808 111 112  52.3044E-18 M=1.0
C4809 110 116  52.3044E-18 M=1.0
C4810 110 115  52.3044E-18 M=1.0
C4811 110 114  52.3044E-18 M=1.0
C4812 110 113  52.3044E-18 M=1.0
C4813 110 112  52.3044E-18 M=1.0
C4814 110 111  52.3044E-18 M=1.0
C4815 109 116  52.3044E-18 M=1.0
C4816 109 115  52.3044E-18 M=1.0
C4817 109 114  52.3044E-18 M=1.0
C4818 109 113  52.3044E-18 M=1.0
C4819 109 112  52.3044E-18 M=1.0
C4820 109 111  52.3044E-18 M=1.0
C4821 109 110  52.3044000000001E-18 M=1.0
C4822 40 111  52.3044E-18 M=1.0
C4823 40 110  52.3044E-18 M=1.0
C4824 40 109  52.3044E-18 M=1.0
C4825 39 111  52.3044E-18 M=1.0
C4826 39 110  52.3044E-18 M=1.0
C4827 39 109  52.3044E-18 M=1.0
C4828 38 111  52.3044E-18 M=1.0
C4829 38 110  52.3044E-18 M=1.0
C4830 38 109  52.3044E-18 M=1.0
C4831 37 111  52.3044E-18 M=1.0
C4832 37 110  52.3044E-18 M=1.0
C4833 37 109  52.3044E-18 M=1.0
C4834 8 111  52.3044E-18 M=1.0
C4835 8 110  52.3044E-18 M=1.0
C4836 8 109  52.3044E-18 M=1.0
C4837 7 111  52.3044E-18 M=1.0
C4838 7 110  52.3044E-18 M=1.0
C4839 7 109  52.3044E-18 M=1.0
C4840 6 111  52.3044E-18 M=1.0
C4841 6 110  52.3044E-18 M=1.0
C4842 6 109  52.3044E-18 M=1.0
C4843 GD 111  3.85713405E-15 M=1.0
C4844 GD 109  2.88170235E-15 M=1.0
C4845 GD 114  209.781899999998E-18 M=1.0
C4846 VD 279  40.0706999999998E-18 M=1.0
C4847 VD 278  53.4276E-18 M=1.0
C4848 VD 145  81.7128000000001E-18 M=1.0
C4849 VD 114  40.0707E-18 M=1.0
C4850 VD 39  53.4276E-18 M=1.0
C4851 GD 278  236.745E-18 M=1.0
C4852 GD 183  44.0136E-18 M=1.0
C4853 GD 39  133.0416E-18 M=1.0
C4854 VD 214  30.4271999999999E-18 M=1.0
C4855 VD 184  30.4272000000001E-18 M=1.0
C4856 279 810  34.9776E-18 M=1.0
C4857 278 810  34.9776E-18 M=1.0
C4858 214 810  69.2001E-18 M=1.0
C4859 184 801  69.2001E-18 M=1.0
C4860 183 184  69.2001E-18 M=1.0
C4861 145 797  34.9776E-18 M=1.0
C4862 135 797  34.9776E-18 M=1.0
C4863 114 801  34.9776E-18 M=1.0
C4864 114 800  34.9776E-18 M=1.0
C4865 114 183  34.9776E-18 M=1.0
C4866 39 801  34.9776E-18 M=1.0
C4867 39 183  34.9776E-18 M=1.0
C4868 8 801  69.9552E-18 M=1.0
C4869 8 800  34.9776E-18 M=1.0
C4870 GD 183  66.4299E-18 M=1.0
C4871 VD 810  66.4299E-18 M=1.0
C4872 VD 801  66.4299E-18 M=1.0
C4873 VD 800  65.9682E-18 M=1.0
C4874 VD 797  65.9682E-18 M=1.0
C4875 278 810  225.9306E-18 M=1.0
C4876 278 279  144.4824E-18 M=1.0
C4877 214 278  71.3196E-18 M=1.0
C4878 180 278  88.1676E-18 M=1.0
C4879 179 800  221.25915E-18 M=1.0
C4880 179 184  126.1368E-18 M=1.0
C4881 179 182  72.5841E-18 M=1.0
C4882 179 180  45.52515E-18 M=1.0
C4883 114 801  52.6203E-18 M=1.0
C4884 39 114  52.3044E-18 M=1.0
C4885 8 801  83.813625E-18 M=1.0
C4886 8 114  52.3044E-18 M=1.0
C4887 GD 39  5.184432E-15 M=1.0
C4888 VD 114  429.136875E-18 M=1.0
C4889 147 354  49.5477E-18 M=1.0
C4890 147 350  49.5477E-18 M=1.0
C4891 147 346  49.5477E-18 M=1.0
C4892 147 342  302.27985E-18 M=1.0
C4893 146 350  49.5477E-18 M=1.0
C4894 146 346  244.8468E-18 M=1.0
C4895 146 342  49.5477E-18 M=1.0
C4896 145 346  49.5477E-18 M=1.0
C4897 145 342  49.5477E-18 M=1.0
C4898 116 411  37.3761E-18 M=1.0
C4899 116 346  49.5477E-18 M=1.0
C4900 116 342  49.5477E-18 M=1.0
C4901 115 411  448.5204E-18 M=1.0
C4902 115 346  49.5477E-18 M=1.0
C4903 115 342  49.5477E-18 M=1.0
C4904 101 415  37.3761E-18 M=1.0
C4905 101 411  37.3761E-18 M=1.0
C4906 101 362  49.5477E-18 M=1.0
C4907 101 358  49.5477E-18 M=1.0
C4908 101 354  49.5477E-18 M=1.0
C4909 101 350  49.5477E-18 M=1.0
C4910 101 346  49.5477E-18 M=1.0
C4911 101 342  49.5477E-18 M=1.0
C4912 101 338  49.5477E-18 M=1.0
C4913 8 801  282.18375E-18 M=1.0
C4914 8 800  99.27765E-18 M=1.0
C4915 8 182  27.774E-18 M=1.0
C4916 8 179  918.8109E-18 M=1.0
C4917 8 114  73.2987E-18 M=1.0
C4918 GD 147  6.5178864E-15 M=1.0
C4919 GD 146  6.8066334E-15 M=1.0
C4920 GD 115  7.1214129E-15 M=1.0
C4921 A0ININ 101  49.5477E-18 M=1.0
C4922 VD 147  40.54545E-18 M=1.0
C4923 VD 146  40.54545E-18 M=1.0
C4924 VD 145  40.54545E-18 M=1.0
C4925 VD 116  40.54545E-18 M=1.0
C4926 VD 115  40.54545E-18 M=1.0
C4927 VD 101  40.54545E-18 M=1.0
C4928 VD 8  225.1044E-18 M=1.0
C4929 A7B3 415  86.9238E-18 M=1.0
C4930 A7B3 411  37.3761E-18 M=1.0
C4931 A7B3 362  49.5477E-18 M=1.0
C4932 A7B3 358  49.5477E-18 M=1.0
C4933 A7B3 354  49.5477E-18 M=1.0
C4934 A7B3 350  49.5477E-18 M=1.0
C4935 A7B3 346  49.5477E-18 M=1.0
C4936 A7B3 342  49.5477E-18 M=1.0
C4937 A7B3 338  49.5477E-18 M=1.0
C4938 A7B3 GD  8.9061066E-15 M=1.0
C4939 A7B3 VD  40.54545E-18 M=1.0
C4940 GD 338  24.5951892E-15 M=1.0
C4941 411 415  37.3761E-18 M=1.0
C4942 166 415  37.3761E-18 M=1.0
C4943 166 411  37.3761E-18 M=1.0
C4944 166 362  49.5477E-18 M=1.0
C4945 166 358  49.5477E-18 M=1.0
C4946 166 354  49.5477E-18 M=1.0
C4947 166 350  49.5477E-18 M=1.0
C4948 166 346  49.5477E-18 M=1.0
C4949 166 342  49.5477E-18 M=1.0
C4950 166 338  49.5477E-18 M=1.0
C4951 165 415  37.3761E-18 M=1.0
C4952 165 411  37.3761E-18 M=1.0
C4953 165 362  49.5477E-18 M=1.0
C4954 165 358  49.5477E-18 M=1.0
C4955 165 354  49.5477E-18 M=1.0
C4956 165 350  49.5477E-18 M=1.0
C4957 165 346  49.5477E-18 M=1.0
C4958 165 342  49.5477E-18 M=1.0
C4959 165 338  49.5477E-18 M=1.0
C4960 164 415  37.3761E-18 M=1.0
C4961 164 411  37.3761E-18 M=1.0
C4962 164 362  49.5477E-18 M=1.0
C4963 164 358  49.5477E-18 M=1.0
C4964 164 354  49.5477E-18 M=1.0
C4965 164 350  49.5477E-18 M=1.0
C4966 164 346  49.5477E-18 M=1.0
C4967 164 342  49.5477E-18 M=1.0
C4968 164 338  49.5477E-18 M=1.0
C4969 134 415  37.3761E-18 M=1.0
C4970 134 411  37.3761E-18 M=1.0
C4971 134 362  49.5477E-18 M=1.0
C4972 134 358  49.5477E-18 M=1.0
C4973 134 354  49.5477E-18 M=1.0
C4974 134 350  49.5477E-18 M=1.0
C4975 134 346  49.5477E-18 M=1.0
C4976 134 342  49.5477E-18 M=1.0
C4977 134 338  49.5477E-18 M=1.0
C4978 133 415  37.3761E-18 M=1.0
C4979 133 411  37.3761E-18 M=1.0
C4980 133 362  49.5477E-18 M=1.0
C4981 133 358  49.5477E-18 M=1.0
C4982 133 354  49.5477E-18 M=1.0
C4983 133 350  49.5477E-18 M=1.0
C4984 133 346  49.5477E-18 M=1.0
C4985 133 342  49.5477E-18 M=1.0
C4986 133 338  49.5477E-18 M=1.0
C4987 GD 165  8.6007312E-15 M=1.0
C4988 GD 133  8.824176E-15 M=1.0
C4989 A0ININ 166  49.5477E-18 M=1.0
C4990 A0ININ 165  49.5477E-18 M=1.0
C4991 A0ININ 164  49.5477E-18 M=1.0
C4992 A0ININ 134  49.5477E-18 M=1.0
C4993 A0ININ 133  49.5477E-18 M=1.0
C4994 VD 166  40.54545E-18 M=1.0
C4995 VD 165  40.54545E-18 M=1.0
C4996 VD 164  40.54545E-18 M=1.0
C4997 VD 134  40.54545E-18 M=1.0
C4998 VD 133  40.54545E-18 M=1.0
C4999 GD 178  139.8546E-18 M=1.0
C5000 GD 176  69.9273000000005E-18 M=1.0
C5001 GD 102  282.852E-18 M=1.0
C5002 VD 208  26.7138000000001E-18 M=1.0
C5003 VD 178  26.7138000000001E-18 M=1.0
C5004 GD 178  214.7382E-18 M=1.0
C5005 GD 175  44.0136E-18 M=1.0
C5006 GD 173  239.9328E-18 M=1.0
C5007 GD 167  133.0416E-18 M=1.0
C5008 VD 204  30.4272000000001E-18 M=1.0
C5009 VD 203  30.4271999999999E-18 M=1.0
C5010 VD 174  30.4272000000001E-18 M=1.0
C5011 VD 173  30.4271999999999E-18 M=1.0
C5012 VD 145  106.6266E-18 M=1.0
C5013 VD 8  106.6266E-18 M=1.0
C5014 180 810  69.9552E-18 M=1.0
C5015 176 178  135E-18 M=1.0
C5016 174 807  34.9776E-18 M=1.0
C5017 174 178  65.0448E-18 M=1.0
C5018 167 178  204.9552E-18 M=1.0
C5019 167 176  100.0224E-18 M=1.0
C5020 145 178  169.9776E-18 M=1.0
C5021 145 176  100.0224E-18 M=1.0
C5022 145 175  34.9776E-18 M=1.0
C5023 135 176  100.0224E-18 M=1.0
C5024 135 175  34.9776E-18 M=1.0
C5025 135 145  139.9104E-18 M=1.0
C5026 25 807  34.9776E-18 M=1.0
C5027 25 208  169.9776E-18 M=1.0
C5028 8 183  69.9552E-18 M=1.0
C5029 GD 411  4.2364098E-15 M=1.0
C5030 GD 178  799.4889E-18 M=1.0
C5031 GD 176  326.322E-18 M=1.0
C5032 GD 175  65.9682E-18 M=1.0
C5033 GD 135  397.0251E-18 M=1.0
C5034 VD 807  65.9682E-18 M=1.0
C5035 203 204  44.1036E-18 M=1.0
C5036 180 810  52.6203E-18 M=1.0
C5037 179 411  52.3044E-18 M=1.0
C5038 179 346  376.6284E-18 M=1.0
C5039 179 342  52.3044E-18 M=1.0
C5040 174 179  45.52515E-18 M=1.0
C5041 174 178  52.3044E-18 M=1.0
C5042 173 179  251.65395E-18 M=1.0
C5043 173 174  44.1036E-18 M=1.0
C5044 25 203  128.547E-18 M=1.0
C5045 GD 203  1.242774675E-15 M=1.0
C5046 VD 180  1.50245145E-15 M=1.0
C5047 VD 179  1.184676075E-15 M=1.0
C5048 VD 8  73.313775E-18 M=1.0
C5049 GD 278  282.852000000001E-18 M=1.0
C5050 GD 184  139.854600000001E-18 M=1.0
C5051 GD 182  69.9273000000009E-18 M=1.0
C5052 GD 39  282.852000000001E-18 M=1.0
C5053 GD 8  254.566800000001E-18 M=1.0
C5054 VD 214  26.7137999999998E-18 M=1.0
C5055 VD 184  26.7137999999998E-18 M=1.0
C5056 VD 180  81.7128000000003E-18 M=1.0
C5057 VD 8  81.7127999999999E-18 M=1.0
C5058 GD 184  214.7382E-18 M=1.0
C5059 GD 182  189.5436E-18 M=1.0
C5060 GD 181  44.0136E-18 M=1.0
C5061 GD 180  164.349000000001E-18 M=1.0
C5062 GD 179  236.745E-18 M=1.0
C5063 GD 114  136.2294E-18 M=1.0
C5064 VD 212  30.4271999999999E-18 M=1.0
C5065 VD 209  30.4272000000001E-18 M=1.0
C5066 VD 182  30.4271999999999E-18 M=1.0
C5067 VD 180  102.8232E-18 M=1.0
C5068 VD 179  30.4272000000001E-18 M=1.0
C5069 279 809  34.9776E-18 M=1.0
C5070 182 184  135E-18 M=1.0
C5071 180 809  34.9776E-18 M=1.0
C5072 180 279  139.9104E-18 M=1.0
C5073 180 278  174.888E-18 M=1.0
C5074 180 184  65.0448E-18 M=1.0
C5075 114 184  139.9104E-18 M=1.0
C5076 114 182  100.0224E-18 M=1.0
C5077 114 181  34.9776E-18 M=1.0
C5078 39 184  204.9552E-18 M=1.0
C5079 39 182  100.0224E-18 M=1.0
C5080 39 114  174.888E-18 M=1.0
C5081 8 184  169.9776E-18 M=1.0
C5082 8 182  100.0224E-18 M=1.0
C5083 8 181  34.9776E-18 M=1.0
C5084 8 114  139.9104E-18 M=1.0
C5085 8 39  174.888E-18 M=1.0
C5086 GD 278  623.8467E-18 M=1.0
C5087 GD 184  799.4889E-18 M=1.0
C5088 GD 182  326.322E-18 M=1.0
C5089 GD 181  65.9682E-18 M=1.0
C5090 GD 114  6.384888E-15 M=1.0
C5091 GD 39  8.61315119999999E-15 M=1.0
C5092 VD 809  65.9682E-18 M=1.0
C5093 VD 180  689.1111E-18 M=1.0
C5094 VD 8  689.1111E-18 M=1.0
C5095 278 809  223.848E-18 M=1.0
C5096 214 279  35.8632E-18 M=1.0
C5097 212 279  44.4186E-18 M=1.0
C5098 212 278  72.5841E-18 M=1.0
C5099 210 279  121.0158E-18 M=1.0
C5100 210 278  148.07475E-18 M=1.0
C5101 209 279  44.1036E-18 M=1.0
C5102 209 278  45.52515E-18 M=1.0
C5103 180 279  665.6148E-18 M=1.0
C5104 180 184  52.3044E-18 M=1.0
C5105 114 179  111.2121E-18 M=1.0
C5106 39 179  154.854E-18 M=1.0
C5107 8 179  298.0287E-18 M=1.0
C5108 GD 180  132.1749E-18 M=1.0
C5109 VD 279  619.3827E-18 M=1.0
C5110 39 184  73.1484E-18 M=1.0
C5111 39 182  39.6918E-18 M=1.0
C5112 39 180  79.011E-18 M=1.0
C5113 39 179  137.6496E-18 M=1.0
C5114 39 114  565.6023E-18 M=1.0
C5115 VD 144  81.7128000000006E-18 M=1.0
C5116 VD 112  40.0706999999999E-18 M=1.0
C5117 VD 38  53.4276E-18 M=1.0
C5118 VD 37  53.4276E-18 M=1.0
C5119 GD 196  44.0135999999999E-18 M=1.0
C5120 VD 144  106.6266E-18 M=1.0
C5121 166 805  34.9776E-18 M=1.0
C5122 166 196  34.9776E-18 M=1.0
C5123 144 805  69.9552E-18 M=1.0
C5124 144 196  69.9552E-18 M=1.0
C5125 144 166  174.888E-18 M=1.0
C5126 38 806  34.9776E-18 M=1.0
C5127 7 806  69.9552E-18 M=1.0
C5128 GD 196  66.4298999999999E-18 M=1.0
C5129 VD 806  66.4299E-18 M=1.0
C5130 VD 805  66.4299000000001E-18 M=1.0
C5131 166 805  52.3044E-18 M=1.0
C5132 166 403  52.3044E-18 M=1.0
C5133 144 805  52.6203E-18 M=1.0
C5134 144 166  52.3044E-18 M=1.0
C5135 113 166  25.6374E-18 M=1.0
C5136 113 144  51.2748E-18 M=1.0
C5137 38 806  52.3044E-18 M=1.0
C5138 38 338  52.3044E-18 M=1.0
C5139 38 196  70.6140000000001E-18 M=1.0
C5140 38 166  33.4161E-18 M=1.0
C5141 7 806  69.6825E-18 M=1.0
C5142 7 338  649.956599999999E-18 M=1.0
C5143 7 38  52.3044E-18 M=1.0
C5144 GD 6  5.841131625E-15 M=1.0
C5145 VD 166  436.5612E-18 M=1.0
C5146 VD 144  421.4259E-18 M=1.0
C5147 VD 38  418.185675E-18 M=1.0
C5148 VD 7  205.25085E-18 M=1.0
C5149 166 403  49.5477E-18 M=1.0
C5150 165 403  49.5477E-18 M=1.0
C5151 164 403  49.5477E-18 M=1.0
C5152 147 403  49.5477E-18 M=1.0
C5153 147 338  49.5477E-18 M=1.0
C5154 147 166  58.6386000000001E-18 M=1.0
C5155 147 165  58.6386E-18 M=1.0
C5156 147 164  49.5477E-18 M=1.0
C5157 146 403  49.5477E-18 M=1.0
C5158 146 338  49.5477E-18 M=1.0
C5159 146 166  58.6386000000001E-18 M=1.0
C5160 146 165  58.6386E-18 M=1.0
C5161 146 164  49.5477E-18 M=1.0
C5162 145 403  49.5477E-18 M=1.0
C5163 145 338  49.5477E-18 M=1.0
C5164 145 166  58.6386000000001E-18 M=1.0
C5165 145 165  58.6386E-18 M=1.0
C5166 145 164  49.5477E-18 M=1.0
C5167 144 403  49.5477E-18 M=1.0
C5168 144 166  58.6386000000001E-18 M=1.0
C5169 144 165  58.6386E-18 M=1.0
C5170 144 164  49.5477E-18 M=1.0
C5171 143 165  58.6386E-18 M=1.0
C5172 143 164  49.5477E-18 M=1.0
C5173 142 164  49.5477E-18 M=1.0
C5174 141 164  3.15049905E-15 M=1.0
C5175 134 403  49.5477E-18 M=1.0
C5176 134 166  58.6386000000001E-18 M=1.0
C5177 134 147  58.6386000000001E-18 M=1.0
C5178 134 146  58.6386000000001E-18 M=1.0
C5179 134 145  58.6386000000001E-18 M=1.0
C5180 134 144  58.6386000000001E-18 M=1.0
C5181 133 403  49.5477E-18 M=1.0
C5182 133 166  58.6386000000001E-18 M=1.0
C5183 133 165  58.6386E-18 M=1.0
C5184 133 147  58.6386E-18 M=1.0
C5185 133 146  58.6386E-18 M=1.0
C5186 133 145  58.6386E-18 M=1.0
C5187 133 144  58.6386E-18 M=1.0
C5188 133 143  58.6386E-18 M=1.0
C5189 116 403  49.5477E-18 M=1.0
C5190 116 338  49.5477E-18 M=1.0
C5191 116 166  58.6386000000001E-18 M=1.0
C5192 116 165  58.6386E-18 M=1.0
C5193 116 164  49.5477E-18 M=1.0
C5194 116 144  58.6386E-18 M=1.0
C5195 116 143  49.5477E-18 M=1.0
C5196 116 142  49.5477E-18 M=1.0
C5197 116 134  58.6386000000001E-18 M=1.0
C5198 116 133  58.6386E-18 M=1.0
C5199 115 403  49.5477E-18 M=1.0
C5200 115 338  49.5477E-18 M=1.0
C5201 115 166  58.6386000000001E-18 M=1.0
C5202 115 165  58.6386E-18 M=1.0
C5203 115 164  49.5477E-18 M=1.0
C5204 115 144  58.6386E-18 M=1.0
C5205 115 143  49.5477E-18 M=1.0
C5206 115 142  49.5477E-18 M=1.0
C5207 115 134  58.6386000000001E-18 M=1.0
C5208 115 133  58.6386E-18 M=1.0
C5209 114 403  49.5477E-18 M=1.0
C5210 114 338  49.5477E-18 M=1.0
C5211 114 166  58.6386000000001E-18 M=1.0
C5212 114 165  58.6386E-18 M=1.0
C5213 114 164  49.5477E-18 M=1.0
C5214 114 144  58.6386E-18 M=1.0
C5215 114 143  49.5477E-18 M=1.0
C5216 114 142  49.5477E-18 M=1.0
C5217 114 134  58.6386000000001E-18 M=1.0
C5218 114 133  58.6386E-18 M=1.0
C5219 113 805  67.3515E-18 M=1.0
C5220 113 403  49.5477E-18 M=1.0
C5221 113 166  58.6386000000001E-18 M=1.0
C5222 113 165  58.6386E-18 M=1.0
C5223 113 164  49.5477E-18 M=1.0
C5224 113 144  58.6386E-18 M=1.0
C5225 113 143  58.6386000000001E-18 M=1.0
C5226 113 142  49.5477E-18 M=1.0
C5227 113 134  58.6386000000001E-18 M=1.0
C5228 113 133  58.6386E-18 M=1.0
C5229 112 165  58.6386E-18 M=1.0
C5230 112 164  49.5477E-18 M=1.0
C5231 112 143  58.6386000000001E-18 M=1.0
C5232 112 142  49.5477E-18 M=1.0
C5233 112 133  58.6386E-18 M=1.0
C5234 101 403  49.5477E-18 M=1.0
C5235 101 166  58.6386000000001E-18 M=1.0
C5236 101 147  49.5477E-18 M=1.0
C5237 101 146  49.5477E-18 M=1.0
C5238 101 145  49.5477E-18 M=1.0
C5239 101 144  49.5477E-18 M=1.0
C5240 101 116  49.5477E-18 M=1.0
C5241 101 115  49.5477E-18 M=1.0
C5242 101 114  49.5477E-18 M=1.0
C5243 101 113  49.5477E-18 M=1.0
C5244 40 235  41.7645E-18 M=1.0
C5245 40 164  49.5477E-18 M=1.0
C5246 39 403  49.5477E-18 M=1.0
C5247 39 338  24.77385E-18 M=1.0
C5248 39 166  58.6386000000001E-18 M=1.0
C5249 39 165  58.6386E-18 M=1.0
C5250 39 164  49.5477E-18 M=1.0
C5251 39 144  58.6386E-18 M=1.0
C5252 39 143  49.5477E-18 M=1.0
C5253 39 142  49.5477E-18 M=1.0
C5254 39 134  58.6386000000001E-18 M=1.0
C5255 39 133  58.6386E-18 M=1.0
C5256 39 113  49.5477E-18 M=1.0
C5257 39 112  49.5477E-18 M=1.0
C5258 39 101  49.5477E-18 M=1.0
C5259 39 40  49.5477E-18 M=1.0
C5260 38 166  577.5147E-18 M=1.0
C5261 38 165  58.6386E-18 M=1.0
C5262 38 164  49.5477E-18 M=1.0
C5263 38 143  58.6386000000001E-18 M=1.0
C5264 38 142  49.5477E-18 M=1.0
C5265 38 134  125.1225E-18 M=1.0
C5266 38 133  58.6386E-18 M=1.0
C5267 38 113  58.6386000000001E-18 M=1.0
C5268 38 112  58.6386000000001E-18 M=1.0
C5269 38 101  39.3174E-18 M=1.0
C5270 37 164  49.5477E-18 M=1.0
C5271 8 403  49.5477E-18 M=1.0
C5272 8 338  49.5477E-18 M=1.0
C5273 8 166  58.6386000000001E-18 M=1.0
C5274 8 165  58.6386E-18 M=1.0
C5275 8 164  49.5477E-18 M=1.0
C5276 8 144  58.6386E-18 M=1.0
C5277 8 143  49.5477E-18 M=1.0
C5278 8 142  49.5477E-18 M=1.0
C5279 8 134  58.6386000000001E-18 M=1.0
C5280 8 133  58.6386E-18 M=1.0
C5281 8 113  49.5477E-18 M=1.0
C5282 8 112  49.5477E-18 M=1.0
C5283 8 101  49.5477E-18 M=1.0
C5284 8 40  49.5477E-18 M=1.0
C5285 8 39  131.5251E-18 M=1.0
C5286 8 38  49.5477E-18 M=1.0
C5287 8 37  49.5477E-18 M=1.0
C5288 7 403  49.5477E-18 M=1.0
C5289 7 166  58.6386000000001E-18 M=1.0
C5290 7 165  58.6386E-18 M=1.0
C5291 7 164  49.5477E-18 M=1.0
C5292 7 144  58.6386E-18 M=1.0
C5293 7 143  49.5477E-18 M=1.0
C5294 7 142  49.5477E-18 M=1.0
C5295 7 134  58.6386000000001E-18 M=1.0
C5296 7 133  58.6386E-18 M=1.0
C5297 7 113  49.5477E-18 M=1.0
C5298 7 112  49.5477E-18 M=1.0
C5299 7 101  49.5477E-18 M=1.0
C5300 7 40  99.0954E-18 M=1.0
C5301 7 39  108.1863E-18 M=1.0
C5302 7 38  49.5477E-18 M=1.0
C5303 7 37  49.5477E-18 M=1.0
C5304 6 165  58.6386E-18 M=1.0
C5305 6 164  49.5477E-18 M=1.0
C5306 6 143  49.5477E-18 M=1.0
C5307 6 142  49.5477E-18 M=1.0
C5308 6 133  58.6386E-18 M=1.0
C5309 6 113  108.1863E-18 M=1.0
C5310 6 112  49.5477E-18 M=1.0
C5311 6 40  129.2265E-18 M=1.0
C5312 6 39  108.1863E-18 M=1.0
C5313 6 38  108.1863E-18 M=1.0
C5314 6 37  49.5477E-18 M=1.0
C5315 GD 164  11.2499091E-15 M=1.0
C5316 GD 145  4.340646E-15 M=1.0
C5317 GD 144  1.3103712E-15 M=1.0
C5318 GD 143  844.5456E-18 M=1.0
C5319 GD 116  8.2731789E-15 M=1.0
C5320 GD 114  2.7015741E-15 M=1.0
C5321 GD 113  1.8319257E-15 M=1.0
C5322 GD 112  1.3098753E-15 M=1.0
C5323 GD 39  3.3671007E-15 M=1.0
C5324 GD 38  721.9035E-18 M=1.0
C5325 GD 7  2.4990561E-15 M=1.0
C5326 GD 6  1.8817425E-15 M=1.0
C5327 VD 113  141.5988E-18 M=1.0
C5328 VD 38  1.5652872E-15 M=1.0
C5329 A7B3 403  49.5477E-18 M=1.0
C5330 A7B3 166  58.6386000000001E-18 M=1.0
C5331 A7B3 165  58.6386E-18 M=1.0
C5332 A7B3 164  49.5477E-18 M=1.0
C5333 A7B3 134  58.6386000000001E-18 M=1.0
C5334 A7B3 133  58.6386E-18 M=1.0
C5335 A7B3 101  49.5477E-18 M=1.0
C5336 GD 794  70.7129999999998E-18 M=1.0
C5337 GD 669  84.0699000000001E-18 M=1.0
C5338 GD 620  69.9272999999999E-18 M=1.0
C5339 GD 615  91.1412E-18 M=1.0
C5340 GD 614  69.9273E-18 M=1.0
C5341 GD 612  47.142E-18 M=1.0
C5342 GD 608  64.4274000000001E-18 M=1.0
C5343 GD 604  70.7129999999998E-18 M=1.0
C5344 GD 595  69.9273000000001E-18 M=1.0
C5345 GD 592  76.2129E-18 M=1.0
C5346 GD 590  47.1419999999998E-18 M=1.0
C5347 GD 585  91.1412E-18 M=1.0
C5348 GD 584  76.2129E-18 M=1.0
C5349 GD 583  70.713E-18 M=1.0
C5350 GD 581  91.1412E-18 M=1.0
C5351 GD 580  76.2129E-18 M=1.0
C5352 GD 579  70.7130000000001E-18 M=1.0
C5353 GD 578  70.7130000000001E-18 M=1.0
C5354 GD 577  91.1411999999998E-18 M=1.0
C5355 GD 575  64.4274E-18 M=1.0
C5356 GD 574  69.9273000000001E-18 M=1.0
C5357 GD 567  91.1412E-18 M=1.0
C5358 GD 564  84.0698999999999E-18 M=1.0
C5359 GD 563  254.5668E-18 M=1.0
C5360 GD 522  139.8546E-18 M=1.0
C5361 GD 521  248.2812E-18 M=1.0
C5362 GD 470  254.5668E-18 M=1.0
C5363 GD 436  209.7819E-18 M=1.0
C5364 GD 384  69.9273E-18 M=1.0
C5365 GD 368  84.0699000000001E-18 M=1.0
C5366 GD 321  139.8546E-18 M=1.0
C5367 GD 304  84.0699E-18 M=1.0
C5368 GD 299  84.0698999999999E-18 M=1.0
C5369 GD 108  204.282E-18 M=1.0
C5370 GD 32  204.282E-18 M=1.0
C5371 GD 30  209.7819E-18 M=1.0
C5372 VD 723  106.8552E-18 M=1.0
C5373 VD 612  73.8558E-18 M=1.0
C5374 VD 608  33.7850999999998E-18 M=1.0
C5375 VD 600  106.8552E-18 M=1.0
C5376 VD 575  33.7851E-18 M=1.0
C5377 VD 521  40.0707000000001E-18 M=1.0
C5378 VD 402  106.8552E-18 M=1.0
C5379 VD 321  26.7138000000001E-18 M=1.0
C5380 VD 140  81.7127999999999E-18 M=1.0
C5381 VD 139  40.0707E-18 M=1.0
C5382 VD 107  53.4276E-18 M=1.0
C5383 VD 32  74.6415000000002E-18 M=1.0
C5384 VD 31  40.0707E-18 M=1.0
C5385 OLI_15 GD  76.2128999999999E-18 M=1.0
C5386 794 795  171.7443E-18 M=1.0
C5387 723 794  75.2327999999999E-18 M=1.0
C5388 669 794  75.2328E-18 M=1.0
C5389 592 604  171.7443E-18 M=1.0
C5390 583 600  75.2328E-18 M=1.0
C5391 583 584  171.7443E-18 M=1.0
C5392 579 600  75.2328E-18 M=1.0
C5393 579 580  171.7443E-18 M=1.0
C5394 578 601  75.2328E-18 M=1.0
C5395 564 604  75.2328E-18 M=1.0
C5396 521 575  75.2328E-18 M=1.0
C5397 402 604  75.2328E-18 M=1.0
C5398 368 578  75.2328E-18 M=1.0
C5399 304 583  75.2328E-18 M=1.0
C5400 299 579  75.2328E-18 M=1.0
C5401 139 608  75.2328E-18 M=1.0
C5402 108 563  454.8447E-18 M=1.0
C5403 32 605  454.8447E-18 M=1.0
C5404 GD 795  226.8738E-18 M=1.0
C5405 GD 794  250.7832E-18 M=1.0
C5406 GD 671  44.0136E-18 M=1.0
C5407 GD 669  174.8907E-18 M=1.0
C5408 GD 620  189.5436E-18 M=1.0
C5409 GD 615  202.6413E-18 M=1.0
C5410 GD 614  189.5436E-18 M=1.0
C5411 GD 612  110.65005E-18 M=1.0
C5412 GD 608  219.5424E-18 M=1.0
C5413 GD 605  191.6757E-18 M=1.0
C5414 GD 604  250.7832E-18 M=1.0
C5415 GD 601  439.87275E-18 M=1.0
C5416 GD 600  368.631E-18 M=1.0
C5417 GD 595  189.5436E-18 M=1.0
C5418 GD 593  130.02975E-18 M=1.0
C5419 GD 592  226.8738E-18 M=1.0
C5420 GD 591  124.9623E-18 M=1.0
C5421 GD 585  202.6413E-18 M=1.0
C5422 GD 584  226.8738E-18 M=1.0
C5423 GD 583  250.7832E-18 M=1.0
C5424 GD 582  309.8007E-18 M=1.0
C5425 GD 581  202.6413E-18 M=1.0
C5426 GD 580  226.8738E-18 M=1.0
C5427 GD 579  250.7832E-18 M=1.0
C5428 GD 578  250.7832E-18 M=1.0
C5429 GD 577  202.6413E-18 M=1.0
C5430 GD 576  259.4115E-18 M=1.0
C5431 GD 575  219.5424E-18 M=1.0
C5432 GD 574  189.5436E-18 M=1.0
C5433 GD 567  202.6413E-18 M=1.0
C5434 GD 564  174.8907E-18 M=1.0
C5435 GD 563  181.134E-18 M=1.0
C5436 GD 522  214.7382E-18 M=1.0
C5437 GD 521  239.9328E-18 M=1.0
C5438 GD 512  44.0136E-18 M=1.0
C5439 GD 505  259.4115E-18 M=1.0
C5440 GD 473  44.0136E-18 M=1.0
C5441 GD 395  44.0136E-18 M=1.0
C5442 GD 376  44.0136E-18 M=1.0
C5443 GD 368  174.8907E-18 M=1.0
C5444 GD 316  164.349E-18 M=1.0
C5445 GD 299  174.8907E-18 M=1.0
C5446 VD 795  30.4272000000001E-18 M=1.0
C5447 VD 794  45.4923E-18 M=1.0
C5448 VD 672  30.4272E-18 M=1.0
C5449 VD 670  102.8232E-18 M=1.0
C5450 VD 669  50.8401E-18 M=1.0
C5451 VD 614  30.4272E-18 M=1.0
C5452 VD 610  30.4272E-18 M=1.0
C5453 VD 608  67.8456000000001E-18 M=1.0
C5454 VD 605  50.8401E-18 M=1.0
C5455 VD 604  45.4923E-18 M=1.0
C5456 VD 601  30.4272E-18 M=1.0
C5457 VD 600  30.4272E-18 M=1.0
C5458 VD 596  30.4272000000001E-18 M=1.0
C5459 VD 595  30.4272E-18 M=1.0
C5460 VD 593  106.39575E-18 M=1.0
C5461 VD 592  30.4272E-18 M=1.0
C5462 VD 591  30.4272E-18 M=1.0
C5463 VD 590  73.4625E-18 M=1.0
C5464 VD 586  80.8164E-18 M=1.0
C5465 VD 585  30.4272E-18 M=1.0
C5466 VD 584  30.4272E-18 M=1.0
C5467 VD 583  45.4923E-18 M=1.0
C5468 VD 582  30.4272E-18 M=1.0
C5469 VD 581  30.4272E-18 M=1.0
C5470 VD 580  30.4272E-18 M=1.0
C5471 VD 579  45.4923E-18 M=1.0
C5472 VD 578  45.4923000000001E-18 M=1.0
C5473 VD 577  30.4272E-18 M=1.0
C5474 VD 576  30.4272E-18 M=1.0
C5475 VD 575  67.8456E-18 M=1.0
C5476 VD 574  30.4272E-18 M=1.0
C5477 VD 567  30.4272E-18 M=1.0
C5478 VD 564  50.8401E-18 M=1.0
C5479 VD 561  30.4272E-18 M=1.0
C5480 VD 554  30.4272000000001E-18 M=1.0
C5481 VD 553  45.4923E-18 M=1.0
C5482 VD 368  50.8401E-18 M=1.0
C5483 VD 108  109.8144E-18 M=1.0
C5484 VD 32  109.8144E-18 M=1.0
C5485 OLI_15 578  171.7443E-18 M=1.0
C5486 OLI_15 GD  226.8738E-18 M=1.0
C5487 OLI_15 VD  30.4272E-18 M=1.0
C5488 723 794  117.0432E-18 M=1.0
C5489 672 901  69.2001E-18 M=1.0
C5490 671 672  69.2001E-18 M=1.0
C5491 669 723  42.0768E-18 M=1.0
C5492 620 882  34.9776E-18 M=1.0
C5493 614 882  34.9776E-18 M=1.0
C5494 614 620  100.0224E-18 M=1.0
C5495 605 882  68.7384E-18 M=1.0
C5496 595 878  34.9776E-18 M=1.0
C5497 590 593  65.27565E-18 M=1.0
C5498 584 600  431.7372E-18 M=1.0
C5499 583 600  182.088E-18 M=1.0
C5500 582 600  65.0448E-18 M=1.0
C5501 581 600  100.0224E-18 M=1.0
C5502 580 600  74.9664E-18 M=1.0
C5503 579 600  117.0432E-18 M=1.0
C5504 578 601  182.088E-18 M=1.0
C5505 577 601  163.4292E-18 M=1.0
C5506 574 878  34.9776E-18 M=1.0
C5507 574 595  100.0224E-18 M=1.0
C5508 563 878  68.7384E-18 M=1.0
C5509 554 877  69.2000999999999E-18 M=1.0
C5510 551 554  69.2001E-18 M=1.0
C5511 521 882  34.9776E-18 M=1.0
C5512 521 620  69.9552E-18 M=1.0
C5513 521 614  100.0224E-18 M=1.0
C5514 521 605  127.7451E-18 M=1.0
C5515 512 563  69.9552E-18 M=1.0
C5516 512 522  69.2000999999999E-18 M=1.0
C5517 505 901  34.9776E-18 M=1.0
C5518 505 672  139.9104E-18 M=1.0
C5519 505 671  34.9776E-18 M=1.0
C5520 505 670  139.9104E-18 M=1.0
C5521 485 512  34.9776E-18 M=1.0
C5522 482 672  204.9552E-18 M=1.0
C5523 482 670  174.888E-18 M=1.0
C5524 482 505  174.888E-18 M=1.0
C5525 473 563  34.9776E-18 M=1.0
C5526 436 512  34.9776E-18 M=1.0
C5527 436 473  34.9776E-18 M=1.0
C5528 402 615  100.0224E-18 M=1.0
C5529 402 610  65.0448E-18 M=1.0
C5530 402 604  182.088E-18 M=1.0
C5531 402 592  74.9664E-18 M=1.0
C5532 402 567  100.0224E-18 M=1.0
C5533 402 564  77.0544E-18 M=1.0
C5534 402 561  65.0448E-18 M=1.0
C5535 395 470  69.9552E-18 M=1.0
C5536 395 401  69.2000999999999E-18 M=1.0
C5537 376 470  34.9776E-18 M=1.0
C5538 368 601  77.0544E-18 M=1.0
C5539 367 395  34.9776E-18 M=1.0
C5540 304 600  77.0544E-18 M=1.0
C5541 299 600  42.0768E-18 M=1.0
C5542 140 877  69.9552E-18 M=1.0
C5543 140 551  69.9552E-18 M=1.0
C5544 139 884  34.9776E-18 M=1.0
C5545 108 878  34.9776E-18 M=1.0
C5546 108 595  100.0224E-18 M=1.0
C5547 108 574  100.0224E-18 M=1.0
C5548 108 563  65.0448E-18 M=1.0
C5549 107 877  34.9776E-18 M=1.0
C5550 107 551  34.9776E-18 M=1.0
C5551 32 882  34.9776E-18 M=1.0
C5552 32 620  100.0224E-18 M=1.0
C5553 32 614  100.0224E-18 M=1.0
C5554 32 605  65.0448E-18 M=1.0
C5555 32 521  104.9328E-18 M=1.0
C5556 31 878  34.9776E-18 M=1.0
C5557 31 595  69.9552E-18 M=1.0
C5558 31 574  100.0224E-18 M=1.0
C5559 31 563  127.7451E-18 M=1.0
C5560 31 108  104.9328E-18 M=1.0
C5561 30 395  34.9776E-18 M=1.0
C5562 30 376  34.9776E-18 M=1.0
C5563 GD 723  1.2955464E-15 M=1.0
C5564 GD 672  799.4889E-18 M=1.0
C5565 GD 620  230.8167E-18 M=1.0
C5566 GD 614  146.8449E-18 M=1.0
C5567 GD 612  2.21557005E-15 M=1.0
C5568 GD 595  230.8167E-18 M=1.0
C5569 GD 574  146.8449E-18 M=1.0
C5570 GD 551  66.4299E-18 M=1.0
C5571 GD 521  456.8508E-18 M=1.0
C5572 GD 512  66.4299E-18 M=1.0
C5573 GD 482  623.8467E-18 M=1.0
C5574 GD 473  65.9682E-18 M=1.0
C5575 GD 402  2.3779206E-15 M=1.0
C5576 GD 395  66.4299E-18 M=1.0
C5577 GD 376  65.9682E-18 M=1.0
C5578 GD 31  16.664031E-15 M=1.0
C5579 VD 882  65.9682E-18 M=1.0
C5580 VD 878  65.9682E-18 M=1.0
C5581 VD 877  66.4299E-18 M=1.0
C5582 VD 670  689.1111E-18 M=1.0
C5583 VD 591  241.3224E-18 M=1.0
C5584 VD 529  55.3986E-18 M=1.0
C5585 VD 108  527.5539E-18 M=1.0
C5586 VD 32  527.5539E-18 M=1.0
C5587 CLK VD  552.83715E-18 M=1.0
C5588 OLI_15 601  74.9664E-18 M=1.0
C5589 723 794  51.7365E-18 M=1.0
C5590 669 723  25.6374E-18 M=1.0
C5591 610 672  73.8396E-18 M=1.0
C5592 610 671  102.276E-18 M=1.0
C5593 608 621  69.741E-18 M=1.0
C5594 596 621  124.4925E-18 M=1.0
C5595 586 612  211.1499E-18 M=1.0
C5596 586 600  47.74275E-18 M=1.0
C5597 582 600  52.3044E-18 M=1.0
C5598 581 582  71.052075E-18 M=1.0
C5599 564 592  69.741E-18 M=1.0
C5600 564 567  145.88775E-18 M=1.0
C5601 561 615  69.741E-18 M=1.0
C5602 561 610  44.1036E-18 M=1.0
C5603 561 604  62.1081E-18 M=1.0
C5604 561 592  28.593E-18 M=1.0
C5605 561 567  69.741E-18 M=1.0
C5606 561 564  126.795375E-18 M=1.0
C5607 554 621  272.0952E-18 M=1.0
C5608 554 596  44.1036E-18 M=1.0
C5609 533 612  28.2303E-18 M=1.0
C5610 533 600  104.256E-18 M=1.0
C5611 533 585  285.679575E-18 M=1.0
C5612 529 584  212.7132E-18 M=1.0
C5613 529 583  93.022425E-18 M=1.0
C5614 529 582  113.8365E-18 M=1.0
C5615 521 882  422.7993E-18 M=1.0
C5616 521 614  52.0524E-18 M=1.0
C5617 521 575  44.7354E-18 M=1.0
C5618 521 574  67.716E-18 M=1.0
C5619 521 563  25.3224E-18 M=1.0
C5620 505 672  148.158E-18 M=1.0
C5621 482 610  92.178E-18 M=1.0
C5622 477 593  936.8406E-18 M=1.0
C5623 477 591  80.6742E-18 M=1.0
C5624 477 590  71.0856E-18 M=1.0
C5625 460 563  64.0935E-18 M=1.0
C5626 460 522  99.9936E-18 M=1.0
C5627 460 512  429.418575E-18 M=1.0
C5628 460 497  71.16255E-18 M=1.0
C5629 460 485  89.7309E-18 M=1.0
C5630 460 473  215.75115E-18 M=1.0
C5631 436 460  51.2748E-18 M=1.0
C5632 402 564  25.6374E-18 M=1.0
C5633 402 561  906.89625E-18 M=1.0
C5634 382 431  52.3044E-18 M=1.0
C5635 368 401  69.4476E-18 M=1.0
C5636 316 431  52.3044E-18 M=1.0
C5637 316 362  517.6224E-18 M=1.0
C5638 304 583  44.1036E-18 M=1.0
C5639 304 582  44.1036E-18 M=1.0
C5640 304 581  142.27965E-18 M=1.0
C5641 304 580  91.9593E-18 M=1.0
C5642 247 431  52.3044E-18 M=1.0
C5643 247 362  52.3044E-18 M=1.0
C5644 140 877  52.6203E-18 M=1.0
C5645 140 596  51.2748E-18 M=1.0
C5646 139 621  51.2748E-18 M=1.0
C5647 139 140  52.3044E-18 M=1.0
C5648 107 877  52.3044E-18 M=1.0
C5649 107 596  25.6374E-18 M=1.0
C5650 107 140  104.6088E-18 M=1.0
C5651 107 139  52.3044E-18 M=1.0
C5652 32 605  43.9335E-18 M=1.0
C5653 31 595  44.1036E-18 M=1.0
C5654 31 563  51.2748E-18 M=1.0
C5655 31 108  25.6374E-18 M=1.0
C5656 30 614  51.7365E-18 M=1.0
C5657 30 605  35.742825E-18 M=1.0
C5658 30 575  69.741E-18 M=1.0
C5659 30 564  44.1036E-18 M=1.0
C5660 30 521  574.165800000001E-18 M=1.0
C5661 GD 669  1.6675263E-15 M=1.0
C5662 GD 605  160.0146E-18 M=1.0
C5663 GD 596  615.3093E-18 M=1.0
C5664 GD 586  1.663607025E-15 M=1.0
C5665 GD 564  129.1149E-18 M=1.0
C5666 GD 561  3.26002815E-15 M=1.0
C5667 GD 533  3.7043829E-15 M=1.0
C5668 GD 460  681.572025E-18 M=1.0
C5669 GD 454  851.89545E-18 M=1.0
C5670 GD 316  768.00735E-18 M=1.0
C5671 GD 140  3.9142458E-15 M=1.0
C5672 GD 107  5.441230575E-15 M=1.0
C5673 A0ININ 382  52.3044E-18 M=1.0
C5674 A0ININ 366  841.973625E-18 M=1.0
C5675 VD 669  979.793325E-18 M=1.0
C5676 VD 586  211.298175E-18 M=1.0
C5677 VD 564  406.623825E-18 M=1.0
C5678 VD 536  888.0165E-18 M=1.0
C5679 VD 460  151.6761E-18 M=1.0
C5680 VD 454  130.6323E-18 M=1.0
C5681 VD 316  78.2577E-18 M=1.0
C5682 VD 140  140.2596E-18 M=1.0
C5683 VD 108  351.63675E-18 M=1.0
C5684 CLK 477  28.2303E-18 M=1.0
C5685 A7B4 621  25.6374E-18 M=1.0
C5686 A7B4 140  52.3044E-18 M=1.0
C5687 A7B4 107  52.3044E-18 M=1.0
C5688 586 612  93.2625E-18 M=1.0
C5689 586 593  151.81515E-18 M=1.0
C5690 586 591  49.5477E-18 M=1.0
C5691 586 590  202.377825E-18 M=1.0
C5692 582 586  127.4634E-18 M=1.0
C5693 576 612  21.0402E-18 M=1.0
C5694 561 610  58.6386E-18 M=1.0
C5695 536 612  21.0402E-18 M=1.0
C5696 536 602  58.6386E-18 M=1.0
C5697 536 601  241.2198E-18 M=1.0
C5698 536 600  124.07985E-18 M=1.0
C5699 536 586  105.8121E-18 M=1.0
C5700 536 584  214.2036E-18 M=1.0
C5701 536 583  43.7148E-18 M=1.0
C5702 536 578  352.15875E-18 M=1.0
C5703 533 586  58.6386E-18 M=1.0
C5704 533 536  63.7317E-18 M=1.0
C5705 529 586  49.5477E-18 M=1.0
C5706 529 536  145.1574E-18 M=1.0
C5707 482 604  43.89705E-18 M=1.0
C5708 482 592  64.7955E-18 M=1.0
C5709 482 567  56.43045E-18 M=1.0
C5710 482 564  128.8224E-18 M=1.0
C5711 482 553  43.89705E-18 M=1.0
C5712 481 586  64.0962E-18 M=1.0
C5713 481 585  114.360075E-18 M=1.0
C5714 477 600  99.0954E-18 M=1.0
C5715 477 586  122.3703E-18 M=1.0
C5716 477 582  63.7317E-18 M=1.0
C5717 477 581  180.979425E-18 M=1.0
C5718 477 533  169.5438E-18 M=1.0
C5719 477 529  476.662725E-18 M=1.0
C5720 459 522  65.853E-18 M=1.0
C5721 454 459  58.6386E-18 M=1.0
C5722 402 610  49.5477E-18 M=1.0
C5723 317 431  49.5477E-18 M=1.0
C5724 317 362  49.5477E-18 M=1.0
C5725 317 321  123.63615E-18 M=1.0
C5726 316 317  43.7148E-18 M=1.0
C5727 304 477  58.6386E-18 M=1.0
C5728 GD 586  2.0485098E-15 M=1.0
C5729 VD 586  628.89615E-18 M=1.0
C5730 VD 576  166.284E-18 M=1.0
C5731 VD 477  1.0104741E-15 M=1.0
C5732 GD 621  254.5668E-18 M=1.0
C5733 GD 494  204.282E-18 M=1.0
C5734 GD 453  64.4273999999999E-18 M=1.0
C5735 GD 442  139.8546E-18 M=1.0
C5736 GD 400  69.9273000000001E-18 M=1.0
C5737 GD 394  69.9273000000001E-18 M=1.0
C5738 GD 386  69.9273000000001E-18 M=1.0
C5739 GD 383  204.282E-18 M=1.0
C5740 GD 377  248.2812E-18 M=1.0
C5741 GD 367  282.852E-18 M=1.0
C5742 GD 243  248.2812E-18 M=1.0
C5743 GD 170  209.7819E-18 M=1.0
C5744 GD 106  282.852E-18 M=1.0
C5745 GD 27  282.851999999999E-18 M=1.0
C5746 VD 621  81.7127999999999E-18 M=1.0
C5747 VD 470  81.7127999999999E-18 M=1.0
C5748 VD 453  33.7850999999998E-18 M=1.0
C5749 VD 442  26.7138E-18 M=1.0
C5750 VD 401  26.7138000000001E-18 M=1.0
C5751 VD 383  74.6414999999998E-18 M=1.0
C5752 VD 374  33.7850999999999E-18 M=1.0
C5753 VD 367  53.4276000000001E-18 M=1.0
C5754 VD 243  40.0707E-18 M=1.0
C5755 VD 170  40.0707E-18 M=1.0
C5756 VD 106  53.4276E-18 M=1.0
C5757 382 383  454.8447E-18 M=1.0
C5758 377 453  75.2328E-18 M=1.0
C5759 243 374  75.2328E-18 M=1.0
C5760 31 546  75.2328E-18 M=1.0
C5761 GD 546  219.5424E-18 M=1.0
C5762 GD 470  181.134E-18 M=1.0
C5763 GD 453  219.5424E-18 M=1.0
C5764 GD 400  189.5436E-18 M=1.0
C5765 GD 394  189.5436E-18 M=1.0
C5766 GD 386  189.5436E-18 M=1.0
C5767 GD 385  44.0135999999999E-18 M=1.0
C5768 GD 383  164.349E-18 M=1.0
C5769 GD 382  253.53E-18 M=1.0
C5770 GD 377  239.9328E-18 M=1.0
C5771 GD 374  219.5424E-18 M=1.0
C5772 GD 367  236.745E-18 M=1.0
C5773 GD 243  239.9328E-18 M=1.0
C5774 GD 170  239.9328E-18 M=1.0
C5775 GD 116  136.2294E-18 M=1.0
C5776 GD 106  133.0416E-18 M=1.0
C5777 GD 31  136.2294E-18 M=1.0
C5778 GD 30  136.2294E-18 M=1.0
C5779 VD 621  102.8232E-18 M=1.0
C5780 VD 546  67.8456E-18 M=1.0
C5781 VD 521  30.4272E-18 M=1.0
C5782 VD 499  30.4272E-18 M=1.0
C5783 VD 494  106.011E-18 M=1.0
C5784 VD 492  30.4272E-18 M=1.0
C5785 VD 453  67.8456E-18 M=1.0
C5786 VD 442  30.4271999999999E-18 M=1.0
C5787 VD 436  30.4272E-18 M=1.0
C5788 VD 401  30.4272E-18 M=1.0
C5789 VD 400  30.4271999999999E-18 M=1.0
C5790 VD 394  30.4272E-18 M=1.0
C5791 VD 386  30.4272E-18 M=1.0
C5792 VD 384  30.4272E-18 M=1.0
C5793 VD 383  106.011E-18 M=1.0
C5794 VD 382  30.4272E-18 M=1.0
C5795 VD 374  67.8455999999999E-18 M=1.0
C5796 VD 367  30.4272E-18 M=1.0
C5797 VD 321  30.4272000000001E-18 M=1.0
C5798 621 856  34.9776E-18 M=1.0
C5799 499 863  34.9776E-18 M=1.0
C5800 494 863  34.9776E-18 M=1.0
C5801 494 499  100.0224E-18 M=1.0
C5802 492 863  34.9776E-18 M=1.0
C5803 492 494  100.0224E-18 M=1.0
C5804 470 863  68.7384E-18 M=1.0
C5805 470 857  69.9552E-18 M=1.0
C5806 470 494  65.0448E-18 M=1.0
C5807 442 862  69.2000999999999E-18 M=1.0
C5808 442 621  169.9776E-18 M=1.0
C5809 441 442  69.2001E-18 M=1.0
C5810 401 857  69.2001E-18 M=1.0
C5811 401 470  169.9776E-18 M=1.0
C5812 400 621  100.0224E-18 M=1.0
C5813 400 442  135E-18 M=1.0
C5814 394 855  34.9776E-18 M=1.0
C5815 386 855  34.9776E-18 M=1.0
C5816 386 394  100.0224E-18 M=1.0
C5817 385 621  34.9776E-18 M=1.0
C5818 383 855  34.9776E-18 M=1.0
C5819 383 442  65.0448E-18 M=1.0
C5820 383 394  100.0224E-18 M=1.0
C5821 383 386  100.0224E-18 M=1.0
C5822 382 855  68.7384E-18 M=1.0
C5823 382 383  65.0448E-18 M=1.0
C5824 377 863  34.9776E-18 M=1.0
C5825 377 494  104.9328E-18 M=1.0
C5826 377 492  100.0224E-18 M=1.0
C5827 377 470  127.7451E-18 M=1.0
C5828 367 857  34.9776E-18 M=1.0
C5829 367 470  174.888E-18 M=1.0
C5830 367 401  204.9552E-18 M=1.0
C5831 321 845  69.2001E-18 M=1.0
C5832 320 321  69.2001E-18 M=1.0
C5833 243 855  34.9776E-18 M=1.0
C5834 243 394  69.9552E-18 M=1.0
C5835 243 386  100.0224E-18 M=1.0
C5836 243 383  104.9328E-18 M=1.0
C5837 243 382  127.7451E-18 M=1.0
C5838 170 862  34.9776E-18 M=1.0
C5839 170 856  34.9776E-18 M=1.0
C5840 170 621  139.9104E-18 M=1.0
C5841 170 442  139.9104E-18 M=1.0
C5842 170 441  34.9776E-18 M=1.0
C5843 170 400  100.0224E-18 M=1.0
C5844 170 385  34.9776E-18 M=1.0
C5845 116 845  34.9776E-18 M=1.0
C5846 116 320  34.9776E-18 M=1.0
C5847 106 862  34.9776E-18 M=1.0
C5848 106 621  174.888E-18 M=1.0
C5849 106 442  204.9552E-18 M=1.0
C5850 106 441  34.9776E-18 M=1.0
C5851 106 400  100.0224E-18 M=1.0
C5852 106 170  174.888E-18 M=1.0
C5853 104 845  69.9552E-18 M=1.0
C5854 104 320  69.9552E-18 M=1.0
C5855 30 857  34.9776E-18 M=1.0
C5856 30 367  174.888E-18 M=1.0
C5857 27 845  34.9776E-18 M=1.0
C5858 27 320  34.9776E-18 M=1.0
C5859 GD 442  799.4889E-18 M=1.0
C5860 GD 401  799.4889E-18 M=1.0
C5861 GD 400  326.322E-18 M=1.0
C5862 GD 394  230.8167E-18 M=1.0
C5863 GD 386  146.8449E-18 M=1.0
C5864 GD 385  65.9682E-18 M=1.0
C5865 GD 377  456.8508E-18 M=1.0
C5866 GD 367  623.8467E-18 M=1.0
C5867 GD 320  66.4299E-18 M=1.0
C5868 GD 243  456.8508E-18 M=1.0
C5869 GD 170  397.0251E-18 M=1.0
C5870 GD 106  11.9797065E-15 M=1.0
C5871 GD 30  16.9522821E-15 M=1.0
C5872 VD 863  65.9682E-18 M=1.0
C5873 VD 857  66.4299E-18 M=1.0
C5874 VD 856  65.9682E-18 M=1.0
C5875 VD 855  65.9682E-18 M=1.0
C5876 VD 845  66.4299E-18 M=1.0
C5877 VD 621  689.1111E-18 M=1.0
C5878 VD 494  527.5539E-18 M=1.0
C5879 VD 470  689.1111E-18 M=1.0
C5880 VD 383  527.5539E-18 M=1.0
C5881 VD 104  689.1111E-18 M=1.0
C5882 521 546  69.741E-18 M=1.0
C5883 485 494  77.9418000000001E-18 M=1.0
C5884 470 857  52.3044E-18 M=1.0
C5885 470 494  25.6374E-18 M=1.0
C5886 453 470  69.741E-18 M=1.0
C5887 436 470  88.2072E-18 M=1.0
C5888 436 453  162.298125E-18 M=1.0
C5889 383 621  25.6374E-18 M=1.0
C5890 383 442  116.5779E-18 M=1.0
C5891 383 400  78.86835E-18 M=1.0
C5892 382 383  25.6374E-18 M=1.0
C5893 377 621  320.904675E-18 M=1.0
C5894 377 494  70.614E-18 M=1.0
C5895 377 470  51.2748E-18 M=1.0
C5896 377 442  103.5792E-18 M=1.0
C5897 377 441  46.2689999999999E-18 M=1.0
C5898 377 400  69.741E-18 M=1.0
C5899 377 383  44.1036E-18 M=1.0
C5900 374 382  69.741E-18 M=1.0
C5901 367 857  52.3044E-18 M=1.0
C5902 367 470  52.3044E-18 M=1.0
C5903 367 394  345.753E-18 M=1.0
C5904 367 386  41.148E-18 M=1.0
C5905 367 383  51.2748E-18 M=1.0
C5906 367 382  113.9508E-18 M=1.0
C5907 243 383  52.3044E-18 M=1.0
C5908 243 382  51.2748E-18 M=1.0
C5909 170 862  83.51595E-18 M=1.0
C5910 170 621  52.3044E-18 M=1.0
C5911 170 383  25.6374E-18 M=1.0
C5912 170 377  124.0308E-18 M=1.0
C5913 116 845  52.3044E-18 M=1.0
C5914 116 247  53.5761E-18 M=1.0
C5915 108 563  25.6374E-18 M=1.0
C5916 106 862  52.3044E-18 M=1.0
C5917 106 621  52.3044E-18 M=1.0
C5918 106 383  25.6374E-18 M=1.0
C5919 106 377  139.2966E-18 M=1.0
C5920 106 170  52.3044E-18 M=1.0
C5921 106 140  52.3044E-18 M=1.0
C5922 106 139  52.3044E-18 M=1.0
C5923 104 116  52.3044E-18 M=1.0
C5924 31 521  515.3598E-18 M=1.0
C5925 30 401  44.1036E-18 M=1.0
C5926 30 367  25.6374E-18 M=1.0
C5927 27 845  52.3044E-18 M=1.0
C5928 27 247  71.4348E-18 M=1.0
C5929 27 116  52.3044E-18 M=1.0
C5930 GD 563  524.07855E-18 M=1.0
C5931 GD 521  737.29665E-18 M=1.0
C5932 GD 470  874.94535E-18 M=1.0
C5933 GD 383  484.0947E-18 M=1.0
C5934 GD 382  2.329821225E-15 M=1.0
C5935 GD 377  1.329911775E-15 M=1.0
C5936 GD 243  2.415585375E-15 M=1.0
C5937 GD 170  627.7554E-18 M=1.0
C5938 GD 30  11.601831375E-15 M=1.0
C5939 VD 494  154.79595E-18 M=1.0
C5940 VD 470  158.934825E-18 M=1.0
C5941 VD 383  154.79595E-18 M=1.0
C5942 VD 377  739.0557E-18 M=1.0
C5943 VD 367  137.7693E-18 M=1.0
C5944 VD 104  356.105925E-18 M=1.0
C5945 VD 30  1.5648525E-15 M=1.0
C5946 VD 27  432.29295E-18 M=1.0
C5947 A7B4 106  52.3044E-18 M=1.0
C5948 459 863  67.0599E-18 M=1.0
C5949 459 494  108.1863E-18 M=1.0
C5950 459 470  58.6386E-18 M=1.0
C5951 377 459  228.975075E-18 M=1.0
C5952 170 862  50.14305E-18 M=1.0
C5953 170 856  205.76025E-18 M=1.0
C5954 170 621  27.3069E-18 M=1.0
C5955 170 400  66.942E-18 M=1.0
C5956 170 383  44.8083E-18 M=1.0
C5957 106 170  63.1206E-18 M=1.0
C5958 GD 459  4.151689875E-15 M=1.0
C5959 VD 459  580.5801E-18 M=1.0
C5960 GD 227  209.7819E-18 M=1.0
C5961 GD 171  282.852E-18 M=1.0
C5962 GD 105  254.5668E-18 M=1.0
C5963 VD 322  26.7138E-18 M=1.0
C5964 VD 227  40.0707E-18 M=1.0
C5965 VD 171  53.4276E-18 M=1.0
C5966 VD 105  81.7127999999998E-18 M=1.0
C5967 GD 442  214.7382E-18 M=1.0
C5968 GD 322  214.7382E-18 M=1.0
C5969 GD 291  44.0136E-18 M=1.0
C5970 GD 289  189.5436E-18 M=1.0
C5971 GD 281  44.0136E-18 M=1.0
C5972 GD 227  239.9328E-18 M=1.0
C5973 GD 171  236.745E-18 M=1.0
C5974 VD 377  30.4271999999999E-18 M=1.0
C5975 VD 322  30.4271999999999E-18 M=1.0
C5976 VD 289  30.4271999999999E-18 M=1.0
C5977 VD 105  106.6266E-18 M=1.0
C5978 322 849  69.2001E-18 M=1.0
C5979 291 322  69.2001E-18 M=1.0
C5980 289 322  135E-18 M=1.0
C5981 227 849  34.9776E-18 M=1.0
C5982 227 834  34.9776E-18 M=1.0
C5983 227 322  139.9104E-18 M=1.0
C5984 227 291  34.9776E-18 M=1.0
C5985 227 289  100.0224E-18 M=1.0
C5986 227 281  34.9776E-18 M=1.0
C5987 171 849  34.9776E-18 M=1.0
C5988 171 322  204.9552E-18 M=1.0
C5989 171 291  34.9776E-18 M=1.0
C5990 171 289  100.0224E-18 M=1.0
C5991 171 227  174.888E-18 M=1.0
C5992 105 849  69.9552E-18 M=1.0
C5993 105 834  34.9776E-18 M=1.0
C5994 105 322  169.9776E-18 M=1.0
C5995 105 291  69.9552E-18 M=1.0
C5996 105 289  100.0224E-18 M=1.0
C5997 105 281  34.9776E-18 M=1.0
C5998 105 227  139.9104E-18 M=1.0
C5999 105 171  174.888E-18 M=1.0
C6000 GD 322  799.4889E-18 M=1.0
C6001 GD 291  66.4299E-18 M=1.0
C6002 GD 289  326.322E-18 M=1.0
C6003 GD 281  65.9682E-18 M=1.0
C6004 GD 227  397.0251E-18 M=1.0
C6005 GD 171  623.8467E-18 M=1.0
C6006 VD 849  66.4299000000001E-18 M=1.0
C6007 VD 834  65.9682E-18 M=1.0
C6008 VD 105  689.1111E-18 M=1.0
C6009 247 289  102.950325E-18 M=1.0
C6010 243 322  103.5792E-18 M=1.0
C6011 243 291  46.2689999999999E-18 M=1.0
C6012 243 289  69.741E-18 M=1.0
C6013 227 849  52.6203E-18 M=1.0
C6014 227 247  25.6374E-18 M=1.0
C6015 227 243  124.0308E-18 M=1.0
C6016 171 849  52.3044E-18 M=1.0
C6017 171 247  25.6374E-18 M=1.0
C6018 171 243  139.2966E-18 M=1.0
C6019 171 227  52.3044E-18 M=1.0
C6020 105 849  69.6825E-18 M=1.0
C6021 105 247  25.6374E-18 M=1.0
C6022 105 243  320.904675E-18 M=1.0
C6023 105 227  52.3044E-18 M=1.0
C6024 105 171  52.3044E-18 M=1.0
C6025 105 140  52.3044E-18 M=1.0
C6026 105 139  52.3044E-18 M=1.0
C6027 104 845  70.1847E-18 M=1.0
C6028 GD 227  232.69815E-18 M=1.0
C6029 GD 105  6.04255095E-15 M=1.0
C6030 A0ININ 247  52.3044E-18 M=1.0
C6031 VD 243  735.5925E-18 M=1.0
C6032 VD 227  183.1896E-18 M=1.0
C6033 VD 171  175.437E-18 M=1.0
C6034 VD 105  299.4201E-18 M=1.0
C6035 A7B4 105  52.3044E-18 M=1.0
C6036 170 442  42.0804E-18 M=1.0
C6037 170 377  44.8083E-18 M=1.0
C6038 170 322  42.7527E-18 M=1.0
C6039 105 170  869.266575E-18 M=1.0
C6040 GD 170  305.5968E-18 M=1.0
C6041 GD 401  139.8546E-18 M=1.0
C6042 GD 374  64.4274E-18 M=1.0
C6043 GD 319  69.9273E-18 M=1.0
C6044 GD 116  209.781899999999E-18 M=1.0
C6045 GD 104  254.566800000001E-18 M=1.0
C6046 VD 116  40.0707E-18 M=1.0
C6047 VD 104  81.7128E-18 M=1.0
C6048 VD 30  40.0707000000001E-18 M=1.0
C6049 VD 27  53.4275999999999E-18 M=1.0
C6050 GD 401  214.7382E-18 M=1.0
C6051 GD 384  189.5436E-18 M=1.0
C6052 GD 321  214.7382E-18 M=1.0
C6053 GD 320  44.0136E-18 M=1.0
C6054 GD 319  189.5436E-18 M=1.0
C6055 GD 318  44.0136E-18 M=1.0
C6056 GD 317  164.349E-18 M=1.0
C6057 GD 27  133.0416E-18 M=1.0
C6058 VD 470  102.8232E-18 M=1.0
C6059 VD 319  30.4271999999999E-18 M=1.0
C6060 VD 104  106.6266E-18 M=1.0
C6061 470 854  34.9776E-18 M=1.0
C6062 384 470  100.0224E-18 M=1.0
C6063 384 401  135E-18 M=1.0
C6064 368 401  65.0448E-18 M=1.0
C6065 367 384  100.0224E-18 M=1.0
C6066 319 321  135E-18 M=1.0
C6067 317 321  65.0448E-18 M=1.0
C6068 116 844  34.9776E-18 M=1.0
C6069 116 321  139.9104E-18 M=1.0
C6070 116 319  100.0224E-18 M=1.0
C6071 116 318  34.9776E-18 M=1.0
C6072 104 844  34.9776E-18 M=1.0
C6073 104 321  169.9776E-18 M=1.0
C6074 104 319  100.0224E-18 M=1.0
C6075 104 318  34.9776E-18 M=1.0
C6076 104 116  139.9104E-18 M=1.0
C6077 30 854  34.9776E-18 M=1.0
C6078 30 470  139.9104E-18 M=1.0
C6079 30 401  139.9104E-18 M=1.0
C6080 30 384  100.0224E-18 M=1.0
C6081 27 321  204.9552E-18 M=1.0
C6082 27 319  100.0224E-18 M=1.0
C6083 27 116  174.888E-18 M=1.0
C6084 27 104  174.888E-18 M=1.0
C6085 GD 384  326.322E-18 M=1.0
C6086 GD 321  799.4889E-18 M=1.0
C6087 GD 319  326.322E-18 M=1.0
C6088 GD 318  65.9682E-18 M=1.0
C6089 GD 116  6.40120410000001E-15 M=1.0
C6090 GD 27  6.8183802E-15 M=1.0
C6091 VD 854  65.9682E-18 M=1.0
C6092 VD 844  65.9682E-18 M=1.0
C6093 367 374  69.741E-18 M=1.0
C6094 317 321  60.876E-18 M=1.0
C6095 247 321  35.7174E-18 M=1.0
C6096 243 367  58.9077E-18 M=1.0
C6097 104 247  71.4348E-18 M=1.0
C6098 GD 367  946.548E-18 M=1.0
C6099 GD 317  357.7185E-18 M=1.0
C6100 GD 247  3.377726775E-15 M=1.0
C6101 GD 596  209.7819E-18 M=1.0
C6102 GD 554  139.8546E-18 M=1.0
C6103 GD 520  69.9273000000001E-18 M=1.0
C6104 GD 140  254.5668E-18 M=1.0
C6105 GD 107  282.852E-18 M=1.0
C6106 VD 596  40.0707E-18 M=1.0
C6107 VD 554  26.7138E-18 M=1.0
C6108 VD 546  33.7850999999998E-18 M=1.0
C6109 VD 494  74.6414999999999E-18 M=1.0
C6110 VD 377  40.0707E-18 M=1.0
C6111 VD 108  74.6414999999999E-18 M=1.0
C6112 GD 596  239.9328E-18 M=1.0
C6113 GD 554  214.7382E-18 M=1.0
C6114 GD 551  44.0135999999999E-18 M=1.0
C6115 GD 520  189.5436E-18 M=1.0
C6116 GD 502  44.0135999999999E-18 M=1.0
C6117 GD 494  164.349E-18 M=1.0
C6118 GD 441  44.0135999999999E-18 M=1.0
C6119 GD 107  133.0416E-18 M=1.0
C6120 VD 520  30.4272000000001E-18 M=1.0
C6121 VD 485  30.4272000000001E-18 M=1.0
C6122 VD 140  106.6266E-18 M=1.0
C6123 621 862  69.9552E-18 M=1.0
C6124 596 877  34.9776E-18 M=1.0
C6125 596 872  34.9776E-18 M=1.0
C6126 554 596  139.9104E-18 M=1.0
C6127 551 596  34.9776E-18 M=1.0
C6128 520 596  100.0224E-18 M=1.0
C6129 520 554  135E-18 M=1.0
C6130 502 596  34.9776E-18 M=1.0
C6131 494 554  65.0448E-18 M=1.0
C6132 441 621  69.9552E-18 M=1.0
C6133 140 872  34.9776E-18 M=1.0
C6134 140 596  139.9104E-18 M=1.0
C6135 140 554  169.9776E-18 M=1.0
C6136 140 520  100.0224E-18 M=1.0
C6137 140 502  34.9776E-18 M=1.0
C6138 107 596  174.888E-18 M=1.0
C6139 107 554  204.9552E-18 M=1.0
C6140 107 520  100.0224E-18 M=1.0
C6141 107 140  174.888E-18 M=1.0
C6142 GD 596  397.0251E-18 M=1.0
C6143 GD 554  799.4889E-18 M=1.0
C6144 GD 520  326.322E-18 M=1.0
C6145 GD 502  65.9682E-18 M=1.0
C6146 GD 441  66.4299E-18 M=1.0
C6147 GD 107  14.0409738E-15 M=1.0
C6148 VD 872  65.9681999999999E-18 M=1.0
C6149 VD 862  66.4299E-18 M=1.0
C6150 VD 140  689.1111E-18 M=1.0
C6151 520 621  41.148E-18 M=1.0
C6152 494 621  44.1036E-18 M=1.0
C6153 494 554  52.3044E-18 M=1.0
C6154 494 520  77.9418E-18 M=1.0
C6155 494 502  51.29595E-18 M=1.0
C6156 485 621  44.1036E-18 M=1.0
C6157 485 554  20.4516E-18 M=1.0
C6158 485 520  20.4516E-18 M=1.0
C6159 140 621  626.757300000002E-18 M=1.0
C6160 107 621  258.51555E-18 M=1.0
C6161 107 494  149.2218E-18 M=1.0
C6162 GD 621  1.348320825E-15 M=1.0
C6163 GD 494  328.56525E-18 M=1.0
C6164 VD 621  652.984875E-18 M=1.0
C6165 459 485  58.6386E-18 M=1.0
C6166 GD 546  64.4273999999999E-18 M=1.0
C6167 GD 499  69.9273000000001E-18 M=1.0
C6168 GD 497  69.9273E-18 M=1.0
C6169 GD 492  69.9273000000001E-18 M=1.0
C6170 GD 485  282.852E-18 M=1.0
C6171 GD 31  248.2812E-18 M=1.0
C6172 VD 563  81.7127999999999E-18 M=1.0
C6173 VD 522  26.7138000000001E-18 M=1.0
C6174 VD 485  53.4276000000002E-18 M=1.0
C6175 VD 436  40.0707000000001E-18 M=1.0
C6176 470 494  454.8447E-18 M=1.0
C6177 GD 499  189.5436E-18 M=1.0
C6178 GD 497  189.5436E-18 M=1.0
C6179 GD 492  189.5436E-18 M=1.0
C6180 GD 485  236.745E-18 M=1.0
C6181 GD 436  239.9328E-18 M=1.0
C6182 VD 563  102.8232E-18 M=1.0
C6183 VD 522  30.4272E-18 M=1.0
C6184 VD 497  30.4272E-18 M=1.0
C6185 563 873  69.9552E-18 M=1.0
C6186 563 870  34.9776E-18 M=1.0
C6187 522 873  69.2001E-18 M=1.0
C6188 522 563  169.9776E-18 M=1.0
C6189 497 563  100.0224E-18 M=1.0
C6190 497 522  135E-18 M=1.0
C6191 492 499  100.0224E-18 M=1.0
C6192 485 873  34.9776E-18 M=1.0
C6193 485 563  174.888E-18 M=1.0
C6194 485 522  204.9552E-18 M=1.0
C6195 485 497  100.0224E-18 M=1.0
C6196 460 522  65.0448E-18 M=1.0
C6197 436 873  34.9776E-18 M=1.0
C6198 436 870  34.9776E-18 M=1.0
C6199 436 563  139.9104E-18 M=1.0
C6200 436 522  139.9104E-18 M=1.0
C6201 436 497  100.0224E-18 M=1.0
C6202 436 485  174.888E-18 M=1.0
C6203 377 499  69.9552E-18 M=1.0
C6204 GD 522  799.4889E-18 M=1.0
C6205 GD 499  230.8167E-18 M=1.0
C6206 GD 497  326.322E-18 M=1.0
C6207 GD 492  146.8449E-18 M=1.0
C6208 GD 485  623.8467E-18 M=1.0
C6209 GD 436  397.0251E-18 M=1.0
C6210 VD 873  66.4299E-18 M=1.0
C6211 VD 870  65.9682E-18 M=1.0
C6212 VD 563  689.1111E-18 M=1.0
C6213 563 873  52.6203E-18 M=1.0
C6214 546 563  147.689775E-18 M=1.0
C6215 485 873  52.3044E-18 M=1.0
C6216 485 563  52.3044E-18 M=1.0
C6217 485 546  25.6374E-18 M=1.0
C6218 485 521  44.36685E-18 M=1.0
C6219 485 499  386.795475E-18 M=1.0
C6220 436 870  52.3044E-18 M=1.0
C6221 436 563  52.3044E-18 M=1.0
C6222 436 499  52.3044E-18 M=1.0
C6223 436 494  25.6374E-18 M=1.0
C6224 436 492  203.3586E-18 M=1.0
C6225 436 485  52.3044E-18 M=1.0
C6226 377 436  51.2748E-18 M=1.0
C6227 30 870  46.95345E-18 M=1.0
C6228 30 563  102.5496E-18 M=1.0
C6229 30 522  69.741E-18 M=1.0
C6230 30 497  96.408E-18 M=1.0
C6231 30 494  51.2748E-18 M=1.0
C6232 30 492  38.6019E-18 M=1.0
C6233 30 485  357.2595E-18 M=1.0
C6234 30 470  95.9049E-18 M=1.0
C6235 30 453  85.56165E-18 M=1.0
C6236 30 436  76.9122E-18 M=1.0
C6237 30 377  51.2748E-18 M=1.0
C6238 GD 485  1.148581575E-15 M=1.0
C6239 GD 436  691.843275E-18 M=1.0
C6240 VD 563  140.2596E-18 M=1.0
C6241 VD 485  353.376E-18 M=1.0
C6242 VD 436  138.4011E-18 M=1.0
C6243 436 459  58.6386E-18 M=1.0
C6244 GD 602  70.7130000000004E-18 M=1.0
C6245 GD 600  593.9892E-18 M=1.0
C6246 GD 531  76.2129E-18 M=1.0
C6247 GD 530  70.713E-18 M=1.0
C6248 GD 479  76.2129E-18 M=1.0
C6249 GD 478  70.713E-18 M=1.0
C6250 GD 434  70.7130000000001E-18 M=1.0
C6251 GD 433  76.2128999999999E-18 M=1.0
C6252 GD 432  91.1412000000002E-18 M=1.0
C6253 GD 430  70.7130000000001E-18 M=1.0
C6254 GD 429  76.2129E-18 M=1.0
C6255 GD 428  91.1412E-18 M=1.0
C6256 GD 426  70.713E-18 M=1.0
C6257 GD 425  76.2129000000001E-18 M=1.0
C6258 GD 424  91.1412000000001E-18 M=1.0
C6259 GD 422  70.713E-18 M=1.0
C6260 GD 421  76.2129E-18 M=1.0
C6261 GD 420  91.1411999999995E-18 M=1.0
C6262 GD 393  593.9892E-18 M=1.0
C6263 GD 359  70.713E-18 M=1.0
C6264 GD 310  84.0699E-18 M=1.0
C6265 GD 267  254.5668E-18 M=1.0
C6266 A_1 GD  84.0699E-18 M=1.0
C6267 VD 393  106.8552E-18 M=1.0
C6268 VD 267  81.7128E-18 M=1.0
C6269 B_7 GD  84.0699000000001E-18 M=1.0
C6270 B_6 GD  84.0699000000001E-18 M=1.0
C6271 B_5 GD  84.0699E-18 M=1.0
C6272 B_4 GD  84.0699000000001E-18 M=1.0
C6273 B_3 GD  84.0699000000001E-18 M=1.0
C6274 530 600  75.2328E-18 M=1.0
C6275 530 531  171.7443E-18 M=1.0
C6276 478 601  75.2328E-18 M=1.0
C6277 478 479  171.7443E-18 M=1.0
C6278 433 434  171.7443E-18 M=1.0
C6279 429 430  171.7443E-18 M=1.0
C6280 425 426  171.7443E-18 M=1.0
C6281 421 422  171.7443E-18 M=1.0
C6282 393 602  66.57525E-18 M=1.0
C6283 393 434  75.2328E-18 M=1.0
C6284 393 430  75.2328E-18 M=1.0
C6285 393 426  75.2328E-18 M=1.0
C6286 393 422  75.2328E-18 M=1.0
C6287 359 375  75.2328E-18 M=1.0
C6288 359 360  171.7443E-18 M=1.0
C6289 310 478  75.2328E-18 M=1.0
C6290 305 530  75.2328E-18 M=1.0
C6291 GD 531  226.8738E-18 M=1.0
C6292 GD 530  250.7832E-18 M=1.0
C6293 GD 479  226.8738E-18 M=1.0
C6294 GD 457  189.5436E-18 M=1.0
C6295 GD 434  250.7832E-18 M=1.0
C6296 GD 433  226.8738E-18 M=1.0
C6297 GD 432  202.6413E-18 M=1.0
C6298 GD 430  250.7832E-18 M=1.0
C6299 GD 429  226.8738E-18 M=1.0
C6300 GD 428  202.6413E-18 M=1.0
C6301 GD 426  250.7832E-18 M=1.0
C6302 GD 425  226.8738E-18 M=1.0
C6303 GD 424  202.6413E-18 M=1.0
C6304 GD 422  250.7832E-18 M=1.0
C6305 GD 421  226.8738E-18 M=1.0
C6306 GD 420  202.6413E-18 M=1.0
C6307 GD 393  357.012E-18 M=1.0
C6308 GD 360  226.8738E-18 M=1.0
C6309 GD 359  250.7832E-18 M=1.0
C6310 GD 310  174.8907E-18 M=1.0
C6311 GD 305  174.8907E-18 M=1.0
C6312 GD 260  239.9328E-18 M=1.0
C6313 GD 28  133.0416E-18 M=1.0
C6314 A_1 359  75.2328E-18 M=1.0
C6315 VD 532  30.4272E-18 M=1.0
C6316 VD 531  30.4272E-18 M=1.0
C6317 VD 484  45.4923000000001E-18 M=1.0
C6318 VD 480  30.4272E-18 M=1.0
C6319 VD 479  30.4272E-18 M=1.0
C6320 VD 478  45.4923E-18 M=1.0
C6321 VD 474  45.4923E-18 M=1.0
C6322 VD 445  30.4272E-18 M=1.0
C6323 VD 434  45.4923000000001E-18 M=1.0
C6324 VD 433  30.4272E-18 M=1.0
C6325 VD 432  30.4272E-18 M=1.0
C6326 VD 431  30.4272E-18 M=1.0
C6327 VD 430  45.4923E-18 M=1.0
C6328 VD 429  30.4272E-18 M=1.0
C6329 VD 428  30.4272E-18 M=1.0
C6330 VD 427  30.4272E-18 M=1.0
C6331 VD 426  45.4923E-18 M=1.0
C6332 VD 425  30.4272E-18 M=1.0
C6333 VD 424  30.4272E-18 M=1.0
C6334 VD 423  30.4272E-18 M=1.0
C6335 VD 422  45.4923E-18 M=1.0
C6336 VD 421  30.4272E-18 M=1.0
C6337 VD 420  30.4272E-18 M=1.0
C6338 VD 419  30.4272E-18 M=1.0
C6339 VD 418  45.4923000000001E-18 M=1.0
C6340 VD 402  30.4272E-18 M=1.0
C6341 VD 393  30.4272E-18 M=1.0
C6342 VD 366  50.8401E-18 M=1.0
C6343 VD 360  30.4272E-18 M=1.0
C6344 VD 359  45.4923E-18 M=1.0
C6345 VD 309  30.4272E-18 M=1.0
C6346 VD 305  50.8401E-18 M=1.0
C6347 VD 298  50.8401E-18 M=1.0
C6348 VD A_1  20.4129E-18 M=1.0
C6349 B_7 434  75.2328E-18 M=1.0
C6350 B_7 VD  20.4129E-18 M=1.0
C6351 B_6 430  75.2328E-18 M=1.0
C6352 B_6 VD  20.4129E-18 M=1.0
C6353 B_5 426  75.2328E-18 M=1.0
C6354 B_5 VD  20.4129E-18 M=1.0
C6355 B_4 422  75.2328E-18 M=1.0
C6356 B_4 VD  20.4129E-18 M=1.0
C6357 B_3 418  75.2328E-18 M=1.0
C6358 B_3 VD  20.4129000000001E-18 M=1.0
C6359 531 600  74.9664E-18 M=1.0
C6360 530 600  182.088E-18 M=1.0
C6361 479 601  74.9664E-18 M=1.0
C6362 478 601  182.088E-18 M=1.0
C6363 445 536  69.9552E-18 M=1.0
C6364 402 602  84.1536E-18 M=1.0
C6365 393 434  117.0432E-18 M=1.0
C6366 393 433  74.9664E-18 M=1.0
C6367 393 430  117.0432E-18 M=1.0
C6368 393 429  74.9664E-18 M=1.0
C6369 393 426  117.0432E-18 M=1.0
C6370 393 425  74.9664E-18 M=1.0
C6371 393 422  117.0432E-18 M=1.0
C6372 393 421  74.9664E-18 M=1.0
C6373 359 427  580.02885E-18 M=1.0
C6374 309 841  69.2001E-18 M=1.0
C6375 308 309  69.2001E-18 M=1.0
C6376 267 841  69.9552E-18 M=1.0
C6377 267 308  69.9552E-18 M=1.0
C6378 28 841  34.9776E-18 M=1.0
C6379 28 308  34.9776E-18 M=1.0
C6380 GD 601  5.20321815E-15 M=1.0
C6381 GD 445  236.2554E-18 M=1.0
C6382 GD 393  1.2379077E-15 M=1.0
C6383 GD 308  66.4299E-18 M=1.0
C6384 A_1 427  34.9776E-18 M=1.0
C6385 A_1 375  42.0768E-18 M=1.0
C6386 VD 841  66.4299E-18 M=1.0
C6387 VD 586  348.0768E-18 M=1.0
C6388 VD 402  299.0493E-18 M=1.0
C6389 VD 366  21.0987E-18 M=1.0
C6390 VD 310  29.03805E-18 M=1.0
C6391 VD 305  29.03805E-18 M=1.0
C6392 B_7 393  42.0768E-18 M=1.0
C6393 B_6 393  42.0768E-18 M=1.0
C6394 B_5 393  87.5088E-18 M=1.0
C6395 B_4 393  87.5088E-18 M=1.0
C6396 B_3 387  42.0768E-18 M=1.0
C6397 434 602  373.77495E-18 M=1.0
C6398 393 602  44.1036E-18 M=1.0
C6399 368 434  44.1036E-18 M=1.0
C6400 368 433  95.5908E-18 M=1.0
C6401 368 393  269.93925E-18 M=1.0
C6402 366 434  86.13495E-18 M=1.0
C6403 366 433  88.2072E-18 M=1.0
C6404 366 393  61.4592E-18 M=1.0
C6405 311 431  1.960081875E-15 M=1.0
C6406 310 430  409.5009E-18 M=1.0
C6407 310 393  35.7174E-18 M=1.0
C6408 305 600  25.6374E-18 M=1.0
C6409 304 426  89.751825E-18 M=1.0
C6410 304 425  88.2072E-18 M=1.0
C6411 304 393  61.4592E-18 M=1.0
C6412 299 424  237.96855E-18 M=1.0
C6413 299 423  96.7239E-18 M=1.0
C6414 299 422  66.94515E-18 M=1.0
C6415 299 421  70.0569E-18 M=1.0
C6416 299 420  70.0569E-18 M=1.0
C6417 299 419  96.7239E-18 M=1.0
C6418 299 418  66.94515E-18 M=1.0
C6419 299 393  51.2748E-18 M=1.0
C6420 298 474  114.240375E-18 M=1.0
C6421 298 422  296.7021E-18 M=1.0
C6422 298 421  79.8939E-18 M=1.0
C6423 298 420  75.861E-18 M=1.0
C6424 298 419  96.408E-18 M=1.0
C6425 298 418  44.1036E-18 M=1.0
C6426 298 393  51.2748E-18 M=1.0
C6427 293 422  143.86005E-18 M=1.0
C6428 293 421  44.1036E-18 M=1.0
C6429 293 420  69.741E-18 M=1.0
C6430 293 419  70.614E-18 M=1.0
C6431 293 393  74.2779E-18 M=1.0
C6432 293 387  245.8368E-18 M=1.0
C6433 28 841  52.3044E-18 M=1.0
C6434 28 267  83.09115E-18 M=1.0
C6435 GD 602  2.3493564E-15 M=1.0
C6436 GD 366  1.214292825E-15 M=1.0
C6437 GD 310  1.424954475E-15 M=1.0
C6438 VD 602  728.01315E-18 M=1.0
C6439 VD 368  963.605925E-18 M=1.0
C6440 VD 366  791.84565E-18 M=1.0
C6441 VD 310  426.58245E-18 M=1.0
C6442 VD 299  1.650374325E-15 M=1.0
C6443 B_6 310  20.4516E-18 M=1.0
C6444 B_4 299  25.6374E-18 M=1.0
C6445 B_4 298  64.2735E-18 M=1.0
C6446 B_4 293  28.3761E-18 M=1.0
C6447 B_3 299  25.6374E-18 M=1.0
C6448 B_3 298  64.2735E-18 M=1.0
C6449 531 536  87.4296E-18 M=1.0
C6450 479 536  131.3874E-18 M=1.0
C6451 478 536  47.12715E-18 M=1.0
C6452 477 536  43.9578E-18 M=1.0
C6453 476 536  64.998E-18 M=1.0
C6454 475 536  36.8019E-18 M=1.0
C6455 474 536  47.12715E-18 M=1.0
C6456 457 586  64.998E-18 M=1.0
C6457 445 586  64.998E-18 M=1.0
C6458 445 536  49.5477E-18 M=1.0
C6459 393 602  58.6386E-18 M=1.0
C6460 393 434  25.02675E-18 M=1.0
C6461 393 432  64.755E-18 M=1.0
C6462 393 431  31.87665E-18 M=1.0
C6463 393 428  64.755E-18 M=1.0
C6464 393 427  43.7148E-18 M=1.0
C6465 393 426  43.7148E-18 M=1.0
C6466 393 424  42.8976E-18 M=1.0
C6467 393 423  43.7148E-18 M=1.0
C6468 393 422  28.1961E-18 M=1.0
C6469 393 420  64.755E-18 M=1.0
C6470 387 418  43.7148E-18 M=1.0
C6471 375 427  49.5477E-18 M=1.0
C6472 368 393  58.6386E-18 M=1.0
C6473 366 393  58.6386E-18 M=1.0
C6474 359 375  31.36545E-18 M=1.0
C6475 311 393  58.6386E-18 M=1.0
C6476 310 536  58.6386E-18 M=1.0
C6477 310 393  58.6386E-18 M=1.0
C6478 305 536  58.6386E-18 M=1.0
C6479 305 393  58.6386E-18 M=1.0
C6480 304 536  58.6386E-18 M=1.0
C6481 304 393  58.6386E-18 M=1.0
C6482 299 536  58.6386E-18 M=1.0
C6483 299 393  58.6386E-18 M=1.0
C6484 298 536  79.6788E-18 M=1.0
C6485 298 393  58.6386E-18 M=1.0
C6486 293 536  58.6386E-18 M=1.0
C6487 293 393  58.6386E-18 M=1.0
C6488 267 317  67.374E-18 M=1.0
C6489 GD 536  2.5440237E-15 M=1.0
C6490 GD 393  1.079244225E-15 M=1.0
C6491 GD 375  688.2723E-18 M=1.0
C6492 A_1 375  21.0402E-18 M=1.0
C6493 B_7 393  21.0402E-18 M=1.0
C6494 B_6 393  21.0402E-18 M=1.0
C6495 B_3 387  21.0402E-18 M=1.0
C6496 GD 382  282.852000000001E-18 M=1.0
C6497 GD 375  593.9892E-18 M=1.0
C6498 GD 365  91.1411999999999E-18 M=1.0
C6499 GD 364  76.2129000000002E-18 M=1.0
C6500 GD 363  70.713E-18 M=1.0
C6501 GD 361  91.1412E-18 M=1.0
C6502 GD 360  76.2129000000001E-18 M=1.0
C6503 GD 315  139.8546E-18 M=1.0
C6504 GD 313  69.9273000000003E-18 M=1.0
C6505 GD 266  209.7819E-18 M=1.0
C6506 GD 29  254.5668E-18 M=1.0
C6507 A_0 GD  84.0699000000001E-18 M=1.0
C6508 VD 602  110.7837E-18 M=1.0
C6509 VD 382  53.4276000000001E-18 M=1.0
C6510 VD 315  26.7137999999999E-18 M=1.0
C6511 VD 266  40.0706999999999E-18 M=1.0
C6512 VD 29  81.7127999999999E-18 M=1.0
C6513 363 375  75.2328E-18 M=1.0
C6514 363 364  171.7443E-18 M=1.0
C6515 GD 602  127.9521E-18 M=1.0
C6516 GD 365  202.6413E-18 M=1.0
C6517 GD 364  226.8738E-18 M=1.0
C6518 GD 363  250.7832E-18 M=1.0
C6519 GD 361  202.6413E-18 M=1.0
C6520 GD 315  214.7382E-18 M=1.0
C6521 GD 314  44.0136E-18 M=1.0
C6522 GD 313  189.5436E-18 M=1.0
C6523 GD 312  44.0136E-18 M=1.0
C6524 GD 266  239.9328E-18 M=1.0
C6525 A0ININ GD  316.7037E-18 M=1.0
C6526 A_0 363  75.2328E-18 M=1.0
C6527 VD 602  77.4747000000001E-18 M=1.0
C6528 VD 375  30.4272E-18 M=1.0
C6529 VD 365  30.4272E-18 M=1.0
C6530 VD 364  30.4272E-18 M=1.0
C6531 VD 363  45.4923E-18 M=1.0
C6532 VD 361  30.4272E-18 M=1.0
C6533 VD 315  30.4272E-18 M=1.0
C6534 VD 313  30.4272E-18 M=1.0
C6535 VD 310  50.8401E-18 M=1.0
C6536 VD 29  106.6266E-18 M=1.0
C6537 VD A_0  20.4129E-18 M=1.0
C6538 382 843  34.9776E-18 M=1.0
C6539 375 427  69.9552E-18 M=1.0
C6540 364 375  74.9664E-18 M=1.0
C6541 363 375  117.0432E-18 M=1.0
C6542 361 427  65.5065E-18 M=1.0
C6543 360 427  100.3302E-18 M=1.0
C6544 360 375  74.9664E-18 M=1.0
C6545 359 375  117.0432E-18 M=1.0
C6546 315 843  69.2001E-18 M=1.0
C6547 315 382  204.9552E-18 M=1.0
C6548 314 382  34.9776E-18 M=1.0
C6549 314 315  69.2001E-18 M=1.0
C6550 313 382  100.0224E-18 M=1.0
C6551 313 315  135E-18 M=1.0
C6552 311 315  65.0448E-18 M=1.0
C6553 266 843  34.9776E-18 M=1.0
C6554 266 842  34.9776E-18 M=1.0
C6555 266 382  174.888E-18 M=1.0
C6556 266 315  139.9104E-18 M=1.0
C6557 266 314  34.9776E-18 M=1.0
C6558 266 313  100.0224E-18 M=1.0
C6559 266 312  34.9776E-18 M=1.0
C6560 29 843  69.9552E-18 M=1.0
C6561 29 842  34.9776E-18 M=1.0
C6562 29 382  174.888E-18 M=1.0
C6563 29 315  169.9776E-18 M=1.0
C6564 29 314  69.9552E-18 M=1.0
C6565 29 313  100.0224E-18 M=1.0
C6566 29 312  34.9776E-18 M=1.0
C6567 29 266  139.9104E-18 M=1.0
C6568 GD 427  6.59417715E-15 M=1.0
C6569 GD 423  4.661667E-15 M=1.0
C6570 GD 382  623.8467E-18 M=1.0
C6571 GD 358  29.18179485E-15 M=1.0
C6572 GD 354  29.17530405E-15 M=1.0
C6573 GD 315  799.4889E-18 M=1.0
C6574 GD 314  66.4299E-18 M=1.0
C6575 GD 313  326.322E-18 M=1.0
C6576 GD 312  65.9682E-18 M=1.0
C6577 GD 266  397.0251E-18 M=1.0
C6578 A_0 375  42.0768E-18 M=1.0
C6579 VD 843  66.4299E-18 M=1.0
C6580 VD 842  65.9682E-18 M=1.0
C6581 VD 431  1.2420846E-15 M=1.0
C6582 VD 427  1.5474816E-15 M=1.0
C6583 VD 354  4.45089465E-15 M=1.0
C6584 VD 29  689.1111E-18 M=1.0
C6585 382 427  158.517E-18 M=1.0
C6586 375 602  44.1036E-18 M=1.0
C6587 368 602  25.6374E-18 M=1.0
C6588 368 375  131.5161E-18 M=1.0
C6589 366 375  87.0966E-18 M=1.0
C6590 365 368  185.75145E-18 M=1.0
C6591 365 366  70.135875E-18 M=1.0
C6592 364 368  117.5238E-18 M=1.0
C6593 364 366  113.8446E-18 M=1.0
C6594 363 366  86.13495E-18 M=1.0
C6595 362 382  257.1633E-18 M=1.0
C6596 314 382  52.3044E-18 M=1.0
C6597 311 427  52.3044E-18 M=1.0
C6598 311 362  52.3044E-18 M=1.0
C6599 311 315  52.3044E-18 M=1.0
C6600 310 427  52.3044E-18 M=1.0
C6601 310 362  408.651525E-18 M=1.0
C6602 310 361  74.06415E-18 M=1.0
C6603 310 315  56.007E-18 M=1.0
C6604 267 354  52.3044E-18 M=1.0
C6605 266 382  67.5702E-18 M=1.0
C6606 247 427  721.475999999999E-18 M=1.0
C6607 29 843  381.9186E-18 M=1.0
C6608 29 382  58.9077E-18 M=1.0
C6609 29 266  113.805E-18 M=1.0
C6610 GD 267  678.402225E-18 M=1.0
C6611 GD 266  874.7937E-18 M=1.0
C6612 A0ININ 602  306.48735E-18 M=1.0
C6613 A0ININ 368  71.13825E-18 M=1.0
C6614 VD 266  174.7026E-18 M=1.0
C6615 VD 247  137.2878E-18 M=1.0
C6616 375 602  58.6386E-18 M=1.0
C6617 368 375  58.6386E-18 M=1.0
C6618 366 375  58.6386E-18 M=1.0
C6619 365 375  64.755E-18 M=1.0
C6620 363 375  43.7148E-18 M=1.0
C6621 362 375  55.8864E-18 M=1.0
C6622 361 375  64.755E-18 M=1.0
C6623 317 427  20.5659E-18 M=1.0
C6624 317 423  49.5477E-18 M=1.0
C6625 317 382  96.579E-18 M=1.0
C6626 317 358  49.5477E-18 M=1.0
C6627 317 354  49.5477E-18 M=1.0
C6628 315 317  963.74295E-18 M=1.0
C6629 313 317  37.71E-18 M=1.0
C6630 311 375  58.6386E-18 M=1.0
C6631 311 317  67.9644E-18 M=1.0
C6632 310 375  58.6386E-18 M=1.0
C6633 310 317  102.3534E-18 M=1.0
C6634 266 317  37.9404E-18 M=1.0
C6635 247 317  58.6386E-18 M=1.0
C6636 29 317  67.374E-18 M=1.0
C6637 GD 317  1.5231708E-15 M=1.0
C6638 A0ININ 375  68.23575E-18 M=1.0
C6639 A_0 375  21.0402E-18 M=1.0
C6640 VD 375  69.5448E-18 M=1.0
C6641 GD 357  91.1412E-18 M=1.0
C6642 GD 356  76.2129000000001E-18 M=1.0
C6643 GD 355  70.7130000000001E-18 M=1.0
C6644 GD 353  91.1412E-18 M=1.0
C6645 GD 352  76.2129000000001E-18 M=1.0
C6646 GD 351  70.713E-18 M=1.0
C6647 GD 349  91.1411999999995E-18 M=1.0
C6648 GD 317  254.5668E-18 M=1.0
C6649 GD 309  139.8546E-18 M=1.0
C6650 GD 307  69.9272999999999E-18 M=1.0
C6651 GD 260  209.7819E-18 M=1.0
C6652 GD 254  209.781899999999E-18 M=1.0
C6653 GD 28  282.852E-18 M=1.0
C6654 A_3 GD  84.0699000000005E-18 M=1.0
C6655 A_2 GD  84.0698999999999E-18 M=1.0
C6656 VD 375  106.8552E-18 M=1.0
C6657 VD 317  81.7128000000001E-18 M=1.0
C6658 VD 309  26.7138E-18 M=1.0
C6659 VD 260  40.0707E-18 M=1.0
C6660 VD 28  53.4276E-18 M=1.0
C6661 355 375  75.2328E-18 M=1.0
C6662 355 356  171.7443E-18 M=1.0
C6663 351 375  75.2328E-18 M=1.0
C6664 351 352  171.7443E-18 M=1.0
C6665 GD 375  364.212E-18 M=1.0
C6666 GD 357  202.6413E-18 M=1.0
C6667 GD 356  226.8738E-18 M=1.0
C6668 GD 355  250.7832E-18 M=1.0
C6669 GD 353  202.6413E-18 M=1.0
C6670 GD 352  226.8738E-18 M=1.0
C6671 GD 351  250.7832E-18 M=1.0
C6672 GD 349  202.6413E-18 M=1.0
C6673 GD 309  214.7382E-18 M=1.0
C6674 GD 308  44.0136E-18 M=1.0
C6675 GD 307  189.5436E-18 M=1.0
C6676 GD 306  44.0136E-18 M=1.0
C6677 GD 304  174.8907E-18 M=1.0
C6678 GD 302  44.0136E-18 M=1.0
C6679 A_3 351  75.2328E-18 M=1.0
C6680 A_2 355  75.2328E-18 M=1.0
C6681 VD 358  193.7304E-18 M=1.0
C6682 VD 357  30.4272E-18 M=1.0
C6683 VD 356  30.4272E-18 M=1.0
C6684 VD 355  45.4923E-18 M=1.0
C6685 VD 353  30.4272E-18 M=1.0
C6686 VD 352  30.4272E-18 M=1.0
C6687 VD 351  45.4923E-18 M=1.0
C6688 VD 317  102.8232E-18 M=1.0
C6689 VD 307  30.4272E-18 M=1.0
C6690 VD 304  50.8401E-18 M=1.0
C6691 VD 303  30.4272E-18 M=1.0
C6692 VD 267  102.8232E-18 M=1.0
C6693 VD A_3  20.4129E-18 M=1.0
C6694 VD A_2  20.4129E-18 M=1.0
C6695 356 375  74.9664E-18 M=1.0
C6696 355 375  117.0432E-18 M=1.0
C6697 352 375  74.9664E-18 M=1.0
C6698 351 375  117.0432E-18 M=1.0
C6699 317 839  69.9552E-18 M=1.0
C6700 307 309  135E-18 M=1.0
C6701 305 309  65.0448E-18 M=1.0
C6702 303 839  69.2001E-18 M=1.0
C6703 302 317  69.9552E-18 M=1.0
C6704 302 303  69.2001E-18 M=1.0
C6705 267 840  34.9776E-18 M=1.0
C6706 267 309  169.9776E-18 M=1.0
C6707 267 307  100.0224E-18 M=1.0
C6708 267 306  34.9776E-18 M=1.0
C6709 261 839  34.9776E-18 M=1.0
C6710 261 302  34.9776E-18 M=1.0
C6711 260 841  34.9776E-18 M=1.0
C6712 260 840  34.9776E-18 M=1.0
C6713 260 309  139.9104E-18 M=1.0
C6714 260 308  34.9776E-18 M=1.0
C6715 260 307  100.0224E-18 M=1.0
C6716 260 306  34.9776E-18 M=1.0
C6717 260 267  139.9104E-18 M=1.0
C6718 254 839  34.9776E-18 M=1.0
C6719 254 317  139.9104E-18 M=1.0
C6720 254 302  34.9776E-18 M=1.0
C6721 28 309  204.9552E-18 M=1.0
C6722 28 307  100.0224E-18 M=1.0
C6723 28 267  174.888E-18 M=1.0
C6724 28 260  174.888E-18 M=1.0
C6725 GD 419  4.7890404E-15 M=1.0
C6726 GD 375  1.2528387E-15 M=1.0
C6727 GD 309  799.4889E-18 M=1.0
C6728 GD 307  326.322E-18 M=1.0
C6729 GD 306  65.9682E-18 M=1.0
C6730 GD 302  66.4299E-18 M=1.0
C6731 GD 261  623.8467E-18 M=1.0
C6732 GD 260  397.0251E-18 M=1.0
C6733 A_3 375  80.0208E-18 M=1.0
C6734 A_2 375  42.0768E-18 M=1.0
C6735 VD 840  65.9682E-18 M=1.0
C6736 VD 839  66.4299E-18 M=1.0
C6737 VD 423  791.6562E-18 M=1.0
C6738 VD 419  791.6562E-18 M=1.0
C6739 VD 267  689.1111E-18 M=1.0
C6740 305 423  52.3044E-18 M=1.0
C6741 305 375  92.187E-18 M=1.0
C6742 305 358  44.1036E-18 M=1.0
C6743 305 357  112.94955E-18 M=1.0
C6744 305 356  140.37885E-18 M=1.0
C6745 305 355  44.1036E-18 M=1.0
C6746 305 354  69.426E-18 M=1.0
C6747 305 353  84.854925E-18 M=1.0
C6748 305 309  52.3044E-18 M=1.0
C6749 304 423  52.3044E-18 M=1.0
C6750 304 375  112.734E-18 M=1.0
C6751 304 356  44.4195E-18 M=1.0
C6752 304 355  66.94515E-18 M=1.0
C6753 304 354  44.4195E-18 M=1.0
C6754 304 353  145.12905E-18 M=1.0
C6755 304 352  91.9593E-18 M=1.0
C6756 261 839  52.88355E-18 M=1.0
C6757 261 419  52.3044E-18 M=1.0
C6758 261 415  52.3044E-18 M=1.0
C6759 261 350  52.3044E-18 M=1.0
C6760 261 317  103.5792E-18 M=1.0
C6761 260 841  52.3044E-18 M=1.0
C6762 260 267  52.3044E-18 M=1.0
C6763 254 839  52.6203E-18 M=1.0
C6764 254 317  52.3044E-18 M=1.0
C6765 254 261  52.3044E-18 M=1.0
C6766 28 260  52.3044E-18 M=1.0
C6767 GD 305  1.862823825E-15 M=1.0
C6768 A_2 305  25.6374E-18 M=1.0
C6769 A_2 304  25.6374E-18 M=1.0
C6770 VD 305  930.34485E-18 M=1.0
C6771 VD 304  1.76805495E-15 M=1.0
C6772 VD 261  523.68615E-18 M=1.0
C6773 VD 260  137.7693E-18 M=1.0
C6774 VD 254  164.0043E-18 M=1.0
C6775 375 423  49.5477E-18 M=1.0
C6776 358 375  68.23575E-18 M=1.0
C6777 357 375  64.755E-18 M=1.0
C6778 355 375  43.7148E-18 M=1.0
C6779 354 375  68.23575E-18 M=1.0
C6780 353 375  64.755E-18 M=1.0
C6781 351 375  37.3761E-18 M=1.0
C6782 317 419  49.5477E-18 M=1.0
C6783 317 415  49.5477E-18 M=1.0
C6784 317 350  49.5477E-18 M=1.0
C6785 309 317  984.30885E-18 M=1.0
C6786 307 317  37.71E-18 M=1.0
C6787 305 375  58.6386E-18 M=1.0
C6788 305 317  74.0844E-18 M=1.0
C6789 304 375  58.6386E-18 M=1.0
C6790 304 317  74.1573E-18 M=1.0
C6791 260 317  37.9404E-18 M=1.0
C6792 28 317  58.9806E-18 M=1.0
C6793 A_2 375  21.0402E-18 M=1.0
C6794 GD 601  742.4865E-18 M=1.0
C6795 GD 553  70.7129999999998E-18 M=1.0
C6796 GD 541  76.2129E-18 M=1.0
C6797 GD 535  91.1411999999996E-18 M=1.0
C6798 GD 534  70.713E-18 M=1.0
C6799 GD 532  91.1412000000001E-18 M=1.0
C6800 GD 514  91.1412E-18 M=1.0
C6801 GD 501  70.7129999999998E-18 M=1.0
C6802 GD 493  76.2129E-18 M=1.0
C6803 GD 484  70.7130000000001E-18 M=1.0
C6804 GD 483  91.1412000000003E-18 M=1.0
C6805 GD 480  91.1412000000001E-18 M=1.0
C6806 GD 468  91.1412E-18 M=1.0
C6807 GD 460  84.0698999999999E-18 M=1.0
C6808 GD 454  84.0698999999999E-18 M=1.0
C6809 GD 402  593.989200000001E-18 M=1.0
C6810 GD 366  84.0699000000001E-18 M=1.0
C6811 GD 311  84.0699000000001E-18 M=1.0
C6812 VD 601  133.569E-18 M=1.0
C6813 OLI_16 GD  76.2129000000003E-18 M=1.0
C6814 OLI_13 GD  76.2128999999999E-18 M=1.0
C6815 541 553  171.7443E-18 M=1.0
C6816 534 601  75.2328E-18 M=1.0
C6817 493 501  171.7443E-18 M=1.0
C6818 484 601  75.2328E-18 M=1.0
C6819 460 553  75.2328E-18 M=1.0
C6820 454 501  75.2328E-18 M=1.0
C6821 402 553  75.2328E-18 M=1.0
C6822 402 501  75.2328E-18 M=1.0
C6823 366 484  75.2328E-18 M=1.0
C6824 311 534  75.2328E-18 M=1.0
C6825 GD 553  250.7832E-18 M=1.0
C6826 GD 541  226.8738E-18 M=1.0
C6827 GD 535  202.6413E-18 M=1.0
C6828 GD 534  250.7832E-18 M=1.0
C6829 GD 533  309.8007E-18 M=1.0
C6830 GD 532  202.6413E-18 M=1.0
C6831 GD 514  202.6413E-18 M=1.0
C6832 GD 501  250.7832E-18 M=1.0
C6833 GD 493  226.8738E-18 M=1.0
C6834 GD 484  250.7832E-18 M=1.0
C6835 GD 483  202.6413E-18 M=1.0
C6836 GD 480  202.6413E-18 M=1.0
C6837 GD 468  202.6413E-18 M=1.0
C6838 GD 460  174.8907E-18 M=1.0
C6839 GD 459  256.2237E-18 M=1.0
C6840 GD 454  174.8907E-18 M=1.0
C6841 GD 402  364.212E-18 M=1.0
C6842 GD 366  174.8907E-18 M=1.0
C6843 GD 311  174.8907E-18 M=1.0
C6844 VD 541  30.4272E-18 M=1.0
C6845 VD 536  30.4272E-18 M=1.0
C6846 VD 535  30.4272E-18 M=1.0
C6847 VD 534  45.4923E-18 M=1.0
C6848 VD 533  30.4272E-18 M=1.0
C6849 VD 514  30.4272E-18 M=1.0
C6850 VD 505  30.4272E-18 M=1.0
C6851 VD 501  45.4923E-18 M=1.0
C6852 VD 493  30.4272E-18 M=1.0
C6853 VD 483  30.4272E-18 M=1.0
C6854 VD 482  30.4272E-18 M=1.0
C6855 VD 481  30.4272E-18 M=1.0
C6856 VD 468  30.4272E-18 M=1.0
C6857 VD 460  50.8401E-18 M=1.0
C6858 VD 459  30.4272E-18 M=1.0
C6859 VD 454  50.8401E-18 M=1.0
C6860 VD 311  50.8401E-18 M=1.0
C6861 OLI_16 484  171.7443E-18 M=1.0
C6862 OLI_16 GD  226.8738E-18 M=1.0
C6863 OLI_16 VD  30.4272E-18 M=1.0
C6864 OLI_13 534  171.7443E-18 M=1.0
C6865 OLI_13 GD  226.8738E-18 M=1.0
C6866 OLI_13 VD  30.4272E-18 M=1.0
C6867 536 601  65.0448E-18 M=1.0
C6868 535 601  100.0224E-18 M=1.0
C6869 534 601  117.0432E-18 M=1.0
C6870 484 601  182.088E-18 M=1.0
C6871 483 601  100.0224E-18 M=1.0
C6872 482 601  65.0448E-18 M=1.0
C6873 481 601  65.0448E-18 M=1.0
C6874 480 601  100.0224E-18 M=1.0
C6875 431 483  101.4264E-18 M=1.0
C6876 402 553  182.088E-18 M=1.0
C6877 402 541  74.9664E-18 M=1.0
C6878 402 514  100.0224E-18 M=1.0
C6879 402 505  65.0448E-18 M=1.0
C6880 402 501  182.088E-18 M=1.0
C6881 402 493  74.9664E-18 M=1.0
C6882 402 468  100.0224E-18 M=1.0
C6883 402 460  77.0544E-18 M=1.0
C6884 402 459  65.0448E-18 M=1.0
C6885 402 454  77.0544E-18 M=1.0
C6886 366 601  77.0544E-18 M=1.0
C6887 311 601  77.0544E-18 M=1.0
C6888 VD 601  117.9648E-18 M=1.0
C6889 VD 600  348.5763E-18 M=1.0
C6890 VD 454  21.0987E-18 M=1.0
C6891 OLI_16 601  74.9664E-18 M=1.0
C6892 OLI_13 601  74.9664E-18 M=1.0
C6893 601 602  1.5536916E-15 M=1.0
C6894 402 505  52.3044E-18 M=1.0
C6895 368 601  272.3382E-18 M=1.0
C6896 368 535  271.9629E-18 M=1.0
C6897 368 484  83.2455E-18 M=1.0
C6898 366 368  126.122625E-18 M=1.0
C6899 311 601  52.3044E-18 M=1.0
C6900 311 483  202.16115E-18 M=1.0
C6901 GD 505  3.920072625E-15 M=1.0
C6902 GD 368  2.395723275E-15 M=1.0
C6903 GD 311  719.688375E-18 M=1.0
C6904 VD 311  502.7175E-18 M=1.0
C6905 482 602  58.6386E-18 M=1.0
C6906 482 601  58.4379E-18 M=1.0
C6907 482 541  64.7955E-18 M=1.0
C6908 482 514  64.7955E-18 M=1.0
C6909 482 501  43.89705E-18 M=1.0
C6910 482 493  64.7955E-18 M=1.0
C6911 482 484  64.755E-18 M=1.0
C6912 482 483  52.40565E-18 M=1.0
C6913 481 601  49.5477E-18 M=1.0
C6914 481 533  1.60994745E-15 M=1.0
C6915 468 482  212.771925E-18 M=1.0
C6916 460 482  77.9094000000001E-18 M=1.0
C6917 454 482  78.1848E-18 M=1.0
C6918 402 482  217.8693E-18 M=1.0
C6919 368 482  58.6386E-18 M=1.0
C6920 366 482  39.92535E-18 M=1.0
C6921 311 482  58.6386E-18 M=1.0
C6922 GD 482  1.4380524E-15 M=1.0
C6923 GD 481  868.17465E-18 M=1.0
C6924 VD 482  1.34798895E-15 M=1.0
C6925 VD 481  321.46515E-18 M=1.0
C6926 OLI_16 482  43.7148E-18 M=1.0
C6927 GD 586  410.1354E-18 M=1.0
C6928 GD 545  70.7130000000003E-18 M=1.0
C6929 GD 544  76.2128999999998E-18 M=1.0
C6930 GD 528  91.1412E-18 M=1.0
C6931 GD 527  76.2128999999999E-18 M=1.0
C6932 GD 526  70.7130000000001E-18 M=1.0
C6933 GD 476  91.1412E-18 M=1.0
C6934 GD 475  76.2128999999999E-18 M=1.0
C6935 GD 474  70.7130000000001E-18 M=1.0
C6936 GD 457  69.9273E-18 M=1.0
C6937 GD 445  69.9273E-18 M=1.0
C6938 GD 305  84.0699E-18 M=1.0
C6939 GD 298  84.0699000000003E-18 M=1.0
C6940 GD 293  84.0699000000003E-18 M=1.0
C6941 VD 536  66.7845E-18 M=1.0
C6942 545 570  75.2328E-18 M=1.0
C6943 544 545  171.7443E-18 M=1.0
C6944 526 600  75.2328E-18 M=1.0
C6945 526 527  171.7443E-18 M=1.0
C6946 474 601  75.2328E-18 M=1.0
C6947 474 475  171.7443E-18 M=1.0
C6948 467 586  454.8447E-18 M=1.0
C6949 298 474  75.2328E-18 M=1.0
C6950 293 526  75.2328E-18 M=1.0
C6951 GD 570  433.0827E-18 M=1.0
C6952 GD 545  250.7832E-18 M=1.0
C6953 GD 544  226.8738E-18 M=1.0
C6954 GD 543  202.6413E-18 M=1.0
C6955 GD 536  309.8007E-18 M=1.0
C6956 GD 528  202.6413E-18 M=1.0
C6957 GD 527  226.8738E-18 M=1.0
C6958 GD 526  250.7832E-18 M=1.0
C6959 GD 478  250.7832E-18 M=1.0
C6960 GD 477  256.2237E-18 M=1.0
C6961 GD 476  202.6413E-18 M=1.0
C6962 GD 475  226.8738E-18 M=1.0
C6963 GD 474  250.7832E-18 M=1.0
C6964 GD 467  257.0922E-18 M=1.0
C6965 GD 445  189.5436E-18 M=1.0
C6966 GD 298  174.8907E-18 M=1.0
C6967 VD 570  59.5791E-18 M=1.0
C6968 VD 545  45.4923E-18 M=1.0
C6969 VD 544  30.4272E-18 M=1.0
C6970 VD 543  30.4272E-18 M=1.0
C6971 VD 530  45.4923E-18 M=1.0
C6972 VD 529  30.4272E-18 M=1.0
C6973 VD 528  30.4272E-18 M=1.0
C6974 VD 527  30.4272E-18 M=1.0
C6975 VD 526  45.4923E-18 M=1.0
C6976 VD 476  30.4272E-18 M=1.0
C6977 VD 475  30.4272E-18 M=1.0
C6978 VD 467  30.4272E-18 M=1.0
C6979 VD 457  30.4272E-18 M=1.0
C6980 VD 293  50.8401E-18 M=1.0
C6981 CLK 545  75.2328E-18 M=1.0
C6982 586 866  34.9776E-18 M=1.0
C6983 536 866  34.9776E-18 M=1.0
C6984 529 600  65.0448E-18 M=1.0
C6985 528 600  100.0224E-18 M=1.0
C6986 527 600  74.9664E-18 M=1.0
C6987 526 600  117.0432E-18 M=1.0
C6988 477 601  65.0448E-18 M=1.0
C6989 476 601  100.0224E-18 M=1.0
C6990 475 601  74.9664E-18 M=1.0
C6991 474 601  182.088E-18 M=1.0
C6992 467 866  68.2767E-18 M=1.0
C6993 467 536  127.7451E-18 M=1.0
C6994 457 866  34.9776E-18 M=1.0
C6995 457 586  100.0224E-18 M=1.0
C6996 457 536  100.0224E-18 M=1.0
C6997 445 866  34.9776E-18 M=1.0
C6998 445 586  100.0224E-18 M=1.0
C6999 445 457  100.0224E-18 M=1.0
C7000 310 601  77.0544E-18 M=1.0
C7001 305 600  77.0544E-18 M=1.0
C7002 298 601  77.0544E-18 M=1.0
C7003 293 600  77.0544E-18 M=1.0
C7004 GD 600  2.4878214E-15 M=1.0
C7005 GD 570  21.0987E-18 M=1.0
C7006 GD 457  157.7223E-18 M=1.0
C7007 VD 866  65.9682E-18 M=1.0
C7008 CLK 570  77.0544E-18 M=1.0
C7009 CLK 545  192.7368E-18 M=1.0
C7010 CLK 544  89.8488E-18 M=1.0
C7011 CLK 543  100.0224E-18 M=1.0
C7012 CLK GD  2.25843705E-15 M=1.0
C7013 545 570  72.3339E-18 M=1.0
C7014 544 570  75.8151E-18 M=1.0
C7015 543 570  75.9204E-18 M=1.0
C7016 529 600  113.7636E-18 M=1.0
C7017 467 866  70.1847E-18 M=1.0
C7018 467 586  136.1862E-18 M=1.0
C7019 467 536  52.3044E-18 M=1.0
C7020 305 601  52.3044E-18 M=1.0
C7021 305 530  98.07165E-18 M=1.0
C7022 305 478  376.0452E-18 M=1.0
C7023 305 310  125.19315E-18 M=1.0
C7024 304 601  52.3044E-18 M=1.0
C7025 304 600  77.9418E-18 M=1.0
C7026 304 528  139.6944E-18 M=1.0
C7027 304 476  139.6944E-18 M=1.0
C7028 299 601  69.885E-18 M=1.0
C7029 299 600  69.885E-18 M=1.0
C7030 299 527  216.9252E-18 M=1.0
C7031 299 526  44.1036E-18 M=1.0
C7032 299 475  216.9252E-18 M=1.0
C7033 299 474  44.1036E-18 M=1.0
C7034 298 601  25.6374E-18 M=1.0
C7035 293 601  52.3044E-18 M=1.0
C7036 293 600  25.6374E-18 M=1.0
C7037 293 526  44.57745E-18 M=1.0
C7038 GD 304  1.769512275E-15 M=1.0
C7039 VD 467  168.255675E-18 M=1.0
C7040 VD 293  543.2184E-18 M=1.0
C7041 570 586  63.7317E-18 M=1.0
C7042 543 586  219.7404E-18 M=1.0
C7043 477 601  49.5477E-18 M=1.0
C7044 477 528  60.79545E-18 M=1.0
C7045 476 477  60.79545E-18 M=1.0
C7046 467 586  104.0544E-18 M=1.0
C7047 CLK 586  49.5477E-18 M=1.0
C7048 GD 750  76.2129E-18 M=1.0
C7049 GD 749  70.7129999999992E-18 M=1.0
C7050 GD 711  64.4273999999997E-18 M=1.0
C7051 GD 709  69.9272999999991E-18 M=1.0
C7052 GD 708  69.9272999999995E-18 M=1.0
C7053 GD 678  139.854599999998E-18 M=1.0
C7054 GD 676  254.566799999999E-18 M=1.0
C7055 GD 670  254.566800000001E-18 M=1.0
C7056 GD 610  209.7819E-18 M=1.0
C7057 VD 678  26.7137999999999E-18 M=1.0
C7058 VD 676  81.7128000000003E-18 M=1.0
C7059 VD 672  26.7138000000001E-18 M=1.0
C7060 VD 670  81.7127999999997E-18 M=1.0
C7061 VD 610  40.0706999999999E-18 M=1.0
C7062 VD 505  40.0707000000001E-18 M=1.0
C7063 VD 459  53.4276000000002E-18 M=1.0
C7064 749 750  171.7443E-18 M=1.0
C7065 724 749  75.2328E-18 M=1.0
C7066 682 710  454.8447E-18 M=1.0
C7067 681 749  75.2328E-18 M=1.0
C7068 GD 750  226.8738E-18 M=1.0
C7069 GD 749  250.7832E-18 M=1.0
C7070 GD 711  219.5424E-18 M=1.0
C7071 GD 709  189.5436E-18 M=1.0
C7072 GD 708  189.5436E-18 M=1.0
C7073 GD 680  44.0135999999999E-18 M=1.0
C7074 GD 679  189.5436E-18 M=1.0
C7075 GD 610  259.4115E-18 M=1.0
C7076 VD 751  30.4271999999999E-18 M=1.0
C7077 VD 750  30.4272000000001E-18 M=1.0
C7078 VD 681  50.8401E-18 M=1.0
C7079 VD 679  30.4271999999999E-18 M=1.0
C7080 VD 678  30.4272000000001E-18 M=1.0
C7081 VD 676  102.8232E-18 M=1.0
C7082 VD 673  30.4272000000001E-18 M=1.0
C7083 724 750  74.9664E-18 M=1.0
C7084 724 749  117.0432E-18 M=1.0
C7085 708 709  100.0224E-18 M=1.0
C7086 678 903  69.2001E-18 M=1.0
C7087 678 679  135E-18 M=1.0
C7088 676 904  34.9776E-18 M=1.0
C7089 676 903  69.9552E-18 M=1.0
C7090 676 680  34.9776E-18 M=1.0
C7091 676 679  100.0224E-18 M=1.0
C7092 676 678  169.9776E-18 M=1.0
C7093 670 902  34.9776E-18 M=1.0
C7094 670 672  169.9776E-18 M=1.0
C7095 650 884  34.9776E-18 M=1.0
C7096 626 884  34.9776E-18 M=1.0
C7097 621 884  68.7384E-18 M=1.0
C7098 610 904  34.9776E-18 M=1.0
C7099 610 903  34.9776E-18 M=1.0
C7100 610 680  34.9776E-18 M=1.0
C7101 610 679  100.0224E-18 M=1.0
C7102 561 708  69.9552E-18 M=1.0
C7103 505 902  34.9776E-18 M=1.0
C7104 459 903  34.9776E-18 M=1.0
C7105 459 679  100.0224E-18 M=1.0
C7106 459 676  174.888E-18 M=1.0
C7107 459 610  174.888E-18 M=1.0
C7108 GD 709  146.8449E-18 M=1.0
C7109 GD 708  230.8167E-18 M=1.0
C7110 GD 680  65.9682E-18 M=1.0
C7111 GD 679  326.322E-18 M=1.0
C7112 GD 459  623.8467E-18 M=1.0
C7113 VD 904  65.9682E-18 M=1.0
C7114 VD 903  66.4299E-18 M=1.0
C7115 VD 902  65.9682E-18 M=1.0
C7116 VD 884  65.9681999999999E-18 M=1.0
C7117 VD 676  689.1111E-18 M=1.0
C7118 A7B4 884  34.9776E-18 M=1.0
C7119 682 710  42.400125E-18 M=1.0
C7120 681 751  147.528E-18 M=1.0
C7121 681 750  69.741E-18 M=1.0
C7122 108 884  52.3044E-18 M=1.0
C7123 VD 681  858.699225E-18 M=1.0
C7124 VD 676  196.96005E-18 M=1.0
C7125 VD 675  174.138975E-18 M=1.0
C7126 VD 31  442.251675E-18 M=1.0
C7127 A7B4 VD  154.79595E-18 M=1.0
C7128 GD 682  204.281999999999E-18 M=1.0
C7129 GD 679  69.9273000000002E-18 M=1.0
C7130 GD 561  248.281200000001E-18 M=1.0
C7131 VD 711  33.7851000000004E-18 M=1.0
C7132 VD 682  74.6414999999993E-18 M=1.0
C7133 VD 561  40.0707000000005E-18 M=1.0
C7134 561 711  75.2328E-18 M=1.0
C7135 GD 710  191.6757E-18 M=1.0
C7136 GD 682  164.349E-18 M=1.0
C7137 GD 681  174.8907E-18 M=1.0
C7138 GD 678  214.7382E-18 M=1.0
C7139 GD 561  259.4115E-18 M=1.0
C7140 VD 711  67.8456000000001E-18 M=1.0
C7141 VD 710  50.8401000000001E-18 M=1.0
C7142 VD 709  30.4272000000001E-18 M=1.0
C7143 VD 708  30.4271999999998E-18 M=1.0
C7144 VD 682  106.011E-18 M=1.0
C7145 710 896  68.7384E-18 M=1.0
C7146 709 896  34.9776E-18 M=1.0
C7147 708 896  34.9776E-18 M=1.0
C7148 682 896  34.9776E-18 M=1.0
C7149 682 710  65.0448000000001E-18 M=1.0
C7150 682 709  100.0224E-18 M=1.0
C7151 682 708  100.0224E-18 M=1.0
C7152 678 681  65.0448E-18 M=1.0
C7153 561 896  34.9776E-18 M=1.0
C7154 561 710  127.7451E-18 M=1.0
C7155 561 709  100.0224E-18 M=1.0
C7156 561 682  104.9328E-18 M=1.0
C7157 GD 678  799.4889E-18 M=1.0
C7158 GD 561  456.8508E-18 M=1.0
C7159 VD 896  65.9681999999999E-18 M=1.0
C7160 VD 682  559.2384E-18 M=1.0
C7161 561 682  52.3044E-18 M=1.0
C7162 30 31  52.3044E-18 M=1.0
C7163 GD 710  2.546952075E-15 M=1.0
C7164 GD 682  318.500325E-18 M=1.0
C7165 GD 681  1.49146785E-15 M=1.0
C7166 GD 108  6.04576575E-15 M=1.0
C7167 GD 31  7.667223975E-15 M=1.0
C7168 VD 682  111.1131E-18 M=1.0
C7169 VD 561  2.7529803E-15 M=1.0
C7170 A7B4 108  104.6088E-18 M=1.0
C7171 GD 673  69.9273000000001E-18 M=1.0
C7172 GD 672  139.854600000001E-18 M=1.0
C7173 GD 650  69.9273E-18 M=1.0
C7174 GD 626  69.9273E-18 M=1.0
C7175 GD 505  209.7819E-18 M=1.0
C7176 GD 482  282.852E-18 M=1.0
C7177 GD 459  282.851999999999E-18 M=1.0
C7178 GD 139  248.2812E-18 M=1.0
C7179 A7B4 GD  204.282000000001E-18 M=1.0
C7180 A7B4 VD  74.6415000000003E-18 M=1.0
C7181 GD 677  44.0136E-18 M=1.0
C7182 GD 676  164.349E-18 M=1.0
C7183 GD 675  174.8907E-18 M=1.0
C7184 GD 674  44.0136E-18 M=1.0
C7185 GD 673  189.5436E-18 M=1.0
C7186 GD 672  214.7382E-18 M=1.0
C7187 GD 650  189.5436E-18 M=1.0
C7188 GD 626  189.5436E-18 M=1.0
C7189 GD 621  181.134E-18 M=1.0
C7190 GD 482  256.2237E-18 M=1.0
C7191 VD 650  30.4272000000001E-18 M=1.0
C7192 VD 626  30.4272000000001E-18 M=1.0
C7193 VD 620  30.4272E-18 M=1.0
C7194 A7B4 621  454.8447E-18 M=1.0
C7195 A7B4 VD  109.8144E-18 M=1.0
C7196 677 678  69.2001E-18 M=1.0
C7197 676 677  69.9552E-18 M=1.0
C7198 672 675  65.0448E-18 M=1.0
C7199 672 673  135E-18 M=1.0
C7200 670 674  34.9776E-18 M=1.0
C7201 670 673  100.0224E-18 M=1.0
C7202 626 650  100.0224E-18 M=1.0
C7203 610 678  139.9104E-18 M=1.0
C7204 610 677  34.9776E-18 M=1.0
C7205 610 676  139.9104E-18 M=1.0
C7206 505 674  34.9776E-18 M=1.0
C7207 505 673  100.0224E-18 M=1.0
C7208 482 673  100.0224E-18 M=1.0
C7209 459 678  204.9552E-18 M=1.0
C7210 459 677  34.9776E-18 M=1.0
C7211 139 650  69.9552E-18 M=1.0
C7212 139 626  100.0224E-18 M=1.0
C7213 139 621  127.7451E-18 M=1.0
C7214 GD 677  66.4299E-18 M=1.0
C7215 GD 674  65.9682E-18 M=1.0
C7216 GD 673  326.322E-18 M=1.0
C7217 GD 650  230.8167E-18 M=1.0
C7218 GD 626  146.8449E-18 M=1.0
C7219 GD 610  397.0251E-18 M=1.0
C7220 GD 505  397.0251E-18 M=1.0
C7221 GD 139  13.9773132E-15 M=1.0
C7222 A7B4 650  100.0224E-18 M=1.0
C7223 A7B4 626  100.0224E-18 M=1.0
C7224 A7B4 621  65.0448000000001E-18 M=1.0
C7225 A7B4 139  104.9328E-18 M=1.0
C7226 A7B4 VD  527.5539E-18 M=1.0
C7227 610 678  80.055E-18 M=1.0
C7228 610 677  103.4424E-18 M=1.0
C7229 610 676  73.8396E-18 M=1.0
C7230 610 675  27.7506E-18 M=1.0
C7231 610 674  102.276E-18 M=1.0
C7232 610 673  50.7951E-18 M=1.0
C7233 610 670  92.178E-18 M=1.0
C7234 505 610  69.1335E-18 M=1.0
C7235 459 610  23.0445E-18 M=1.0
C7236 108 626  69.156E-18 M=1.0
C7237 108 139  104.6088E-18 M=1.0
C7238 32 521  85.5747E-18 M=1.0
C7239 31 650  52.3044E-18 M=1.0
C7240 31 626  52.3044E-18 M=1.0
C7241 31 139  104.6088E-18 M=1.0
C7242 30 620  287.0676E-18 M=1.0
C7243 30 32  59.9373E-18 M=1.0
C7244 GD 676  309.8817E-18 M=1.0
C7245 VD 521  501.19065E-18 M=1.0
C7246 VD 32  174.0339E-18 M=1.0
C7247 A7B4 139  104.6088E-18 M=1.0
C7248 A7B4 31  104.6088E-18 M=1.0
C7249 459 677  49.5477E-18 M=1.0
C7250 459 610  68.8248E-18 M=1.0
C7251 459 561  68.8248E-18 M=1.0
C7252 108 459  58.6386E-18 M=1.0
C7253 32 459  58.6386E-18 M=1.0
C7254 31 459  58.6386E-18 M=1.0
C7255 30 459  117.2772E-18 M=1.0
C7256 GD 757  91.1411999999995E-18 M=1.0
C7257 GD 756  76.2128999999996E-18 M=1.0
C7258 GD 755  70.7129999999992E-18 M=1.0
C7259 GD 754  91.141200000001E-18 M=1.0
C7260 GD 753  76.2129000000002E-18 M=1.0
C7261 GD 752  70.713E-18 M=1.0
C7262 GD 751  91.1411999999999E-18 M=1.0
C7263 GD 724  593.989199999996E-18 M=1.0
C7264 GD 712  84.0699000000005E-18 M=1.0
C7265 GD 710  84.0698999999988E-18 M=1.0
C7266 VD 724  106.855199999999E-18 M=1.0
C7267 755 756  171.7443E-18 M=1.0
C7268 752 753  171.7443E-18 M=1.0
C7269 724 755  75.2328E-18 M=1.0
C7270 724 752  75.2328E-18 M=1.0
C7271 712 755  75.2327999999998E-18 M=1.0
C7272 710 752  75.2328E-18 M=1.0
C7273 GD 757  202.6413E-18 M=1.0
C7274 GD 756  226.8738E-18 M=1.0
C7275 GD 755  250.7832E-18 M=1.0
C7276 GD 754  202.6413E-18 M=1.0
C7277 GD 753  226.8738E-18 M=1.0
C7278 GD 752  250.783199999999E-18 M=1.0
C7279 GD 751  202.641300000001E-18 M=1.0
C7280 GD 724  364.212E-18 M=1.0
C7281 GD 712  174.8907E-18 M=1.0
C7282 GD S_16  183.8277E-18 M=1.0
C7283 GD S_15  183.8277E-18 M=1.0
C7284 GD S_14  183.8277E-18 M=1.0
C7285 VD 757  30.4272000000001E-18 M=1.0
C7286 VD 756  30.4272000000001E-18 M=1.0
C7287 VD 755  45.4922999999997E-18 M=1.0
C7288 VD 754  30.4272000000001E-18 M=1.0
C7289 VD 753  30.4272000000001E-18 M=1.0
C7290 VD 752  45.4923000000001E-18 M=1.0
C7291 VD 724  30.4272000000001E-18 M=1.0
C7292 VD 712  50.8401E-18 M=1.0
C7293 VD S_16  30.4272000000001E-18 M=1.0
C7294 VD S_15  30.4271999999998E-18 M=1.0
C7295 VD S_14  30.4271999999999E-18 M=1.0
C7296 724 756  74.9664000000001E-18 M=1.0
C7297 724 755  117.0432E-18 M=1.0
C7298 724 753  74.9664E-18 M=1.0
C7299 724 752  117.0432E-18 M=1.0
C7300 712 724  80.0208E-18 M=1.0
C7301 710 724  42.0768E-18 M=1.0
C7302 GD 710  21.0987E-18 M=1.0
C7303 GD S_15  34.33095E-18 M=1.0
C7304 GD S_14  34.33095E-18 M=1.0
C7305 VD 712  29.03805E-18 M=1.0
C7306 VD GD  3.90024045E-15 M=1.0
C7307 724 757  69.741E-18 M=1.0
C7308 724 755  44.1036E-18 M=1.0
C7309 724 754  69.741E-18 M=1.0
C7310 724 752  44.1036E-18 M=1.0
C7311 724 751  69.741E-18 M=1.0
C7312 712 757  69.741E-18 M=1.0
C7313 712 756  69.741E-18 M=1.0
C7314 712 724  41.08545E-18 M=1.0
C7315 710 724  25.6374E-18 M=1.0
C7316 681 724  89.0478E-18 M=1.0
C7317 681 721  89.7624000000001E-18 M=1.0
C7318 S_16 724  44.1036E-18 M=1.0
C7319 S_16 712  131.699025E-18 M=1.0
C7320 S_15 724  44.1036E-18 M=1.0
C7321 S_14 724  44.1036E-18 M=1.0
C7322 GD 724  2.0065428E-15 M=1.0
C7323 GD 712  2.098269E-15 M=1.0
C7324 VD 724  308.66085E-18 M=1.0
C7325 VD 712  432.533475E-18 M=1.0
C7326 VD 710  132.12225E-18 M=1.0
C7327 GD 796  91.1412E-18 M=1.0
C7328 GD 795  76.2129000000001E-18 M=1.0
C7329 GD 748  91.1411999999983E-18 M=1.0
C7330 GD 747  76.2129E-18 M=1.0
C7331 GD 746  70.7130000000004E-18 M=1.0
C7332 GD 681  84.0699000000005E-18 M=1.0
C7333 GD 675  84.0698999999997E-18 M=1.0
C7334 746 747  171.7443E-18 M=1.0
C7335 724 746  75.2328E-18 M=1.0
C7336 675 746  75.2328E-18 M=1.0
C7337 GD 796  202.6413E-18 M=1.0
C7338 GD 748  202.6413E-18 M=1.0
C7339 GD 747  226.8738E-18 M=1.0
C7340 GD 746  250.7832E-18 M=1.0
C7341 GD S_13  183.8277E-18 M=1.0
C7342 GD S_12  183.8277E-18 M=1.0
C7343 VD 796  30.4271999999999E-18 M=1.0
C7344 VD 749  45.4923000000001E-18 M=1.0
C7345 VD 748  30.4272000000001E-18 M=1.0
C7346 VD 747  30.4271999999999E-18 M=1.0
C7347 VD 746  45.4923E-18 M=1.0
C7348 VD 675  50.8400999999999E-18 M=1.0
C7349 VD S_13  30.4272000000001E-18 M=1.0
C7350 VD S_12  30.4271999999999E-18 M=1.0
C7351 724 747  74.9664E-18 M=1.0
C7352 724 746  117.0432E-18 M=1.0
C7353 723 795  74.9664E-18 M=1.0
C7354 681 724  42.0768E-18 M=1.0
C7355 675 724  42.0768E-18 M=1.0
C7356 GD 724  1.2748851E-15 M=1.0
C7357 GD S_13  34.33095E-18 M=1.0
C7358 GD S_12  31.6845E-18 M=1.0
C7359 724 749  44.1036E-18 M=1.0
C7360 724 748  69.741E-18 M=1.0
C7361 724 746  44.1036E-18 M=1.0
C7362 723 796  69.741E-18 M=1.0
C7363 675 746  44.1036E-18 M=1.0
C7364 675 724  51.2748E-18 M=1.0
C7365 675 721  61.5321E-18 M=1.0
C7366 S_13 724  44.1036E-18 M=1.0
C7367 S_12 723  44.1036E-18 M=1.0
C7368 GD 723  2.26080225E-15 M=1.0
C7369 GD 675  2.33458965E-15 M=1.0
C7370 GD 786  76.2129E-18 M=1.0
C7371 GD 785  70.713E-18 M=1.0
C7372 GD 723  593.989199999999E-18 M=1.0
C7373 GD 689  254.5668E-18 M=1.0
C7374 GD 646  254.566799999999E-18 M=1.0
C7375 GD 640  254.5668E-18 M=1.0
C7376 GD 639  84.0699E-18 M=1.0
C7377 GD 481  282.852E-18 M=1.0
C7378 VD 685  26.7138E-18 M=1.0
C7379 VD 666  26.7138E-18 M=1.0
C7380 VD 646  81.7127999999999E-18 M=1.0
C7381 VD 640  81.7128E-18 M=1.0
C7382 VD 586  100.5696E-18 M=1.0
C7383 VD 576  40.0706999999999E-18 M=1.0
C7384 VD 533  66.7845000000001E-18 M=1.0
C7385 VD 482  53.4276000000001E-18 M=1.0
C7386 VD 481  53.4276000000001E-18 M=1.0
C7387 VD 477  100.5696E-18 M=1.0
C7388 785 786  171.7443E-18 M=1.0
C7389 723 785  75.2328E-18 M=1.0
C7390 639 785  75.2328E-18 M=1.0
C7391 GD 787  202.6413E-18 M=1.0
C7392 GD 786  226.8738E-18 M=1.0
C7393 GD 665  44.0136E-18 M=1.0
C7394 GD 639  174.8907E-18 M=1.0
C7395 GD 481  256.2237E-18 M=1.0
C7396 VD 787  30.4272E-18 M=1.0
C7397 VD 786  30.4272E-18 M=1.0
C7398 VD 688  50.8401E-18 M=1.0
C7399 VD 686  30.4272E-18 M=1.0
C7400 VD 685  30.4272E-18 M=1.0
C7401 VD 667  30.4272E-18 M=1.0
C7402 VD 666  30.4272E-18 M=1.0
C7403 VD 646  102.8232E-18 M=1.0
C7404 VD 642  30.4272E-18 M=1.0
C7405 723 786  74.9664E-18 M=1.0
C7406 723 785  117.0432E-18 M=1.0
C7407 689 893  69.9552E-18 M=1.0
C7408 685 905  69.2001E-18 M=1.0
C7409 670 901  69.9552E-18 M=1.0
C7410 666 899  69.2001E-18 M=1.0
C7411 646 900  34.9776E-18 M=1.0
C7412 646 899  69.9552E-18 M=1.0
C7413 646 665  69.9552E-18 M=1.0
C7414 642 893  69.2001E-18 M=1.0
C7415 641 689  69.9552E-18 M=1.0
C7416 641 642  69.2001E-18 M=1.0
C7417 640 906  34.9776E-18 M=1.0
C7418 640 905  69.9552E-18 M=1.0
C7419 586 893  34.9776E-18 M=1.0
C7420 586 642  204.9552E-18 M=1.0
C7421 586 641  34.9776E-18 M=1.0
C7422 576 900  34.9776E-18 M=1.0
C7423 576 899  34.9776E-18 M=1.0
C7424 576 646  139.9104E-18 M=1.0
C7425 536 893  34.9776E-18 M=1.0
C7426 536 641  34.9776E-18 M=1.0
C7427 533 906  34.9776E-18 M=1.0
C7428 533 905  34.9776E-18 M=1.0
C7429 482 901  34.9776E-18 M=1.0
C7430 481 899  34.9776E-18 M=1.0
C7431 481 646  174.888E-18 M=1.0
C7432 477 905  34.9776E-18 M=1.0
C7433 477 640  174.888E-18 M=1.0
C7434 GD 665  66.4299E-18 M=1.0
C7435 GD 481  623.8467E-18 M=1.0
C7436 GD 477  623.8467E-18 M=1.0
C7437 VD 906  65.9682E-18 M=1.0
C7438 VD 905  66.4299E-18 M=1.0
C7439 VD 901  66.4299E-18 M=1.0
C7440 VD 900  65.9682E-18 M=1.0
C7441 VD 899  66.4299E-18 M=1.0
C7442 VD 646  689.1111E-18 M=1.0
C7443 VD 640  689.1111E-18 M=1.0
C7444 VD 639  29.03805E-18 M=1.0
C7445 646 899  69.6825E-18 M=1.0
C7446 645 900  74.2599E-18 M=1.0
C7447 640 905  69.6825E-18 M=1.0
C7448 639 906  74.2599E-18 M=1.0
C7449 586 641  56.8818E-18 M=1.0
C7450 586 590  56.8818E-18 M=1.0
C7451 536 642  56.8818E-18 M=1.0
C7452 536 641  56.8818E-18 M=1.0
C7453 536 612  113.7636E-18 M=1.0
C7454 481 899  234.7938E-18 M=1.0
C7455 481 666  76.6107E-18 M=1.0
C7456 481 646  405.3825E-18 M=1.0
C7457 481 645  56.8818E-18 M=1.0
C7458 477 905  227.517075E-18 M=1.0
C7459 477 685  80.35515E-18 M=1.0
C7460 477 640  402.7896E-18 M=1.0
C7461 477 639  56.8818E-18 M=1.0
C7462 GD 670  247.25565E-18 M=1.0
C7463 GD 645  1.9995849E-15 M=1.0
C7464 GD 536  858.996E-18 M=1.0
C7465 GD 477  3.954024E-15 M=1.0
C7466 VD 670  193.864275E-18 M=1.0
C7467 VD 640  1.043168625E-15 M=1.0
C7468 VD 639  526.500675E-18 M=1.0
C7469 VD 536  1.2198537E-15 M=1.0
C7470 GD 667  69.9272999999996E-18 M=1.0
C7471 GD 666  139.854600000001E-18 M=1.0
C7472 GD 643  69.9273000000002E-18 M=1.0
C7473 GD 642  139.8546E-18 M=1.0
C7474 GD 628  70.7129999999998E-18 M=1.0
C7475 GD 625  76.2129E-18 M=1.0
C7476 GD 605  84.0698999999999E-18 M=1.0
C7477 GD 576  209.7819E-18 M=1.0
C7478 GD 536  370.0647E-18 M=1.0
C7479 VD 642  26.7137999999999E-18 M=1.0
C7480 625 628  171.7443E-18 M=1.0
C7481 605 628  75.2328E-18 M=1.0
C7482 402 628  75.2328E-18 M=1.0
C7483 GD 670  164.349E-18 M=1.0
C7484 GD 668  44.0136E-18 M=1.0
C7485 GD 667  189.5436E-18 M=1.0
C7486 GD 666  214.7382E-18 M=1.0
C7487 GD 646  164.349E-18 M=1.0
C7488 GD 645  174.8907E-18 M=1.0
C7489 GD 644  44.0136E-18 M=1.0
C7490 GD 643  189.5436E-18 M=1.0
C7491 GD 642  214.7382E-18 M=1.0
C7492 GD 628  250.7832E-18 M=1.0
C7493 GD 625  226.8738E-18 M=1.0
C7494 GD 586  256.2237E-18 M=1.0
C7495 VD 689  102.8232E-18 M=1.0
C7496 VD 643  30.4272E-18 M=1.0
C7497 VD 628  45.4923E-18 M=1.0
C7498 VD 625  30.4272E-18 M=1.0
C7499 VD 615  30.4272E-18 M=1.0
C7500 689 894  34.9776E-18 M=1.0
C7501 670 671  69.9552E-18 M=1.0
C7502 666 669  65.0448E-18 M=1.0
C7503 666 667  135E-18 M=1.0
C7504 665 666  69.2001E-18 M=1.0
C7505 646 668  34.9776E-18 M=1.0
C7506 646 667  100.0224E-18 M=1.0
C7507 646 666  169.9776E-18 M=1.0
C7508 644 689  34.9776E-18 M=1.0
C7509 643 689  100.0224E-18 M=1.0
C7510 642 689  169.9776E-18 M=1.0
C7511 642 645  65.0448E-18 M=1.0
C7512 642 643  135E-18 M=1.0
C7513 586 689  174.888E-18 M=1.0
C7514 586 643  100.0224E-18 M=1.0
C7515 576 668  34.9776E-18 M=1.0
C7516 576 667  100.0224E-18 M=1.0
C7517 576 666  139.9104E-18 M=1.0
C7518 576 665  34.9776E-18 M=1.0
C7519 536 894  34.9776E-18 M=1.0
C7520 536 689  139.9104E-18 M=1.0
C7521 536 644  34.9776E-18 M=1.0
C7522 536 643  100.0224E-18 M=1.0
C7523 536 642  139.9104E-18 M=1.0
C7524 536 586  209.8656E-18 M=1.0
C7525 482 671  34.9776E-18 M=1.0
C7526 481 667  100.0224E-18 M=1.0
C7527 481 666  204.9552E-18 M=1.0
C7528 481 665  34.9776E-18 M=1.0
C7529 481 576  174.888E-18 M=1.0
C7530 402 628  117.0432E-18 M=1.0
C7531 402 625  74.9664E-18 M=1.0
C7532 402 605  77.0544E-18 M=1.0
C7533 GD 671  66.4299E-18 M=1.0
C7534 GD 668  65.9682E-18 M=1.0
C7535 GD 667  326.322E-18 M=1.0
C7536 GD 666  799.4889E-18 M=1.0
C7537 GD 645  31.6845E-18 M=1.0
C7538 GD 644  65.9682E-18 M=1.0
C7539 GD 643  326.322E-18 M=1.0
C7540 GD 642  799.4889E-18 M=1.0
C7541 GD 586  623.8467E-18 M=1.0
C7542 GD 576  397.0251E-18 M=1.0
C7543 GD 536  706.0833E-18 M=1.0
C7544 VD 894  65.9682E-18 M=1.0
C7545 VD 689  689.1111E-18 M=1.0
C7546 VD 612  110.7972E-18 M=1.0
C7547 VD 605  29.03805E-18 M=1.0
C7548 646 894  52.3044E-18 M=1.0
C7549 646 689  346.494375E-18 M=1.0
C7550 646 666  52.3044E-18 M=1.0
C7551 645 668  73.7334E-18 M=1.0
C7552 645 667  56.8818E-18 M=1.0
C7553 645 666  56.8818E-18 M=1.0
C7554 645 646  107.5266E-18 M=1.0
C7555 643 646  558.80415E-18 M=1.0
C7556 642 646  56.3148E-18 M=1.0
C7557 610 628  69.872625E-18 M=1.0
C7558 610 625  69.79365E-18 M=1.0
C7559 610 615  79.972875E-18 M=1.0
C7560 605 610  25.6374E-18 M=1.0
C7561 586 646  67.5702E-18 M=1.0
C7562 576 689  324.4266E-18 M=1.0
C7563 576 666  246.65355E-18 M=1.0
C7564 576 665  52.3044E-18 M=1.0
C7565 576 646  315.6687E-18 M=1.0
C7566 576 645  282.6234E-18 M=1.0
C7567 576 642  52.3044E-18 M=1.0
C7568 576 586  52.3044E-18 M=1.0
C7569 561 628  62.1081E-18 M=1.0
C7570 561 625  28.593E-18 M=1.0
C7571 561 605  25.6374E-18 M=1.0
C7572 536 646  77.796E-18 M=1.0
C7573 536 590  113.7636E-18 M=1.0
C7574 536 576  52.3044E-18 M=1.0
C7575 505 670  113.2389E-18 M=1.0
C7576 505 666  56.007E-18 M=1.0
C7577 482 505  30.8232E-18 M=1.0
C7578 481 894  100.081125E-18 M=1.0
C7579 481 689  52.3044E-18 M=1.0
C7580 481 643  51.4809E-18 M=1.0
C7581 481 642  80.5347E-18 M=1.0
C7582 481 586  52.3044E-18 M=1.0
C7583 481 576  67.1076E-18 M=1.0
C7584 481 536  324.86895E-18 M=1.0
C7585 402 610  51.2748E-18 M=1.0
C7586 GD 646  856.746675E-18 M=1.0
C7587 GD 610  3.34608705E-15 M=1.0
C7588 GD 576  809.1252E-18 M=1.0
C7589 GD 481  522.3132E-18 M=1.0
C7590 VD 646  788.16735E-18 M=1.0
C7591 VD 610  37.6677E-18 M=1.0
C7592 VD 605  901.50705E-18 M=1.0
C7593 VD 576  114.6987E-18 M=1.0
C7594 VD 505  37.6677E-18 M=1.0
C7595 VD 481  207.556425E-18 M=1.0
C7596 576 590  49.5477E-18 M=1.0
C7597 536 576  63.7317E-18 M=1.0
C7598 482 671  49.5477E-18 M=1.0
C7599 482 628  43.89705E-18 M=1.0
C7600 482 625  64.7955E-18 M=1.0
C7601 482 615  64.7955E-18 M=1.0
C7602 482 610  112.5801E-18 M=1.0
C7603 482 605  86.0620500000001E-18 M=1.0
C7604 482 561  93.85155E-18 M=1.0
C7605 482 505  112.5801E-18 M=1.0
C7606 481 612  240.6915E-18 M=1.0
C7607 481 590  49.5477E-18 M=1.0
C7608 481 576  63.7317E-18 M=1.0
C7609 481 536  63.7317E-18 M=1.0
C7610 GD 576  546.5736E-18 M=1.0
C7611 GD 695  254.5668E-18 M=1.0
C7612 GD 686  69.9273E-18 M=1.0
C7613 GD 685  139.8546E-18 M=1.0
C7614 GD 637  69.9273E-18 M=1.0
C7615 GD 636  139.8546E-18 M=1.0
C7616 GD 582  370.0647E-18 M=1.0
C7617 GD 538  410.135399999999E-18 M=1.0
C7618 GD 477  410.1354E-18 M=1.0
C7619 VD 695  81.7127999999998E-18 M=1.0
C7620 VD 689  81.7128E-18 M=1.0
C7621 VD 636  26.7138000000001E-18 M=1.0
C7622 VD 590  73.8558E-18 M=1.0
C7623 VD 582  66.7845E-18 M=1.0
C7624 VD 538  100.5696E-18 M=1.0
C7625 GD 689  164.349E-18 M=1.0
C7626 GD 687  44.0136E-18 M=1.0
C7627 GD 686  189.5436E-18 M=1.0
C7628 GD 685  214.7382E-18 M=1.0
C7629 GD 684  44.0136E-18 M=1.0
C7630 GD 641  44.0136E-18 M=1.0
C7631 GD 640  164.349E-18 M=1.0
C7632 GD 638  44.0136E-18 M=1.0
C7633 GD 637  189.5436E-18 M=1.0
C7634 GD 636  214.7382E-18 M=1.0
C7635 GD 635  44.0136E-18 M=1.0
C7636 GD 590  122.5332E-18 M=1.0
C7637 GD 538  256.2237E-18 M=1.0
C7638 VD 695  102.8232E-18 M=1.0
C7639 VD 640  102.8232E-18 M=1.0
C7640 VD 639  50.8401E-18 M=1.0
C7641 VD 637  30.4272E-18 M=1.0
C7642 VD 636  30.4272E-18 M=1.0
C7643 VD 612  66.54825E-18 M=1.0
C7644 695 892  34.9776E-18 M=1.0
C7645 695 891  69.9552E-18 M=1.0
C7646 685 688  65.0448E-18 M=1.0
C7647 685 686  135E-18 M=1.0
C7648 684 685  69.2001E-18 M=1.0
C7649 640 687  34.9776E-18 M=1.0
C7650 640 686  100.0224E-18 M=1.0
C7651 640 685  169.9776E-18 M=1.0
C7652 640 684  69.9552E-18 M=1.0
C7653 638 695  34.9776E-18 M=1.0
C7654 637 695  100.0224E-18 M=1.0
C7655 636 891  69.2001E-18 M=1.0
C7656 636 695  169.9776E-18 M=1.0
C7657 636 639  65.0448E-18 M=1.0
C7658 636 637  135E-18 M=1.0
C7659 635 695  69.9552E-18 M=1.0
C7660 635 636  69.2001E-18 M=1.0
C7661 582 892  34.9776E-18 M=1.0
C7662 582 891  34.9776E-18 M=1.0
C7663 582 695  139.9104E-18 M=1.0
C7664 582 638  34.9776E-18 M=1.0
C7665 582 637  100.0224E-18 M=1.0
C7666 582 636  139.9104E-18 M=1.0
C7667 582 635  34.9776E-18 M=1.0
C7668 538 891  34.9776E-18 M=1.0
C7669 538 695  174.888E-18 M=1.0
C7670 538 637  100.0224E-18 M=1.0
C7671 538 636  204.9552E-18 M=1.0
C7672 538 635  34.9776E-18 M=1.0
C7673 533 687  34.9776E-18 M=1.0
C7674 533 686  100.0224E-18 M=1.0
C7675 533 685  139.9104E-18 M=1.0
C7676 533 684  34.9776E-18 M=1.0
C7677 533 640  139.9104E-18 M=1.0
C7678 477 686  100.0224E-18 M=1.0
C7679 477 685  204.9552E-18 M=1.0
C7680 477 684  34.9776E-18 M=1.0
C7681 477 533  209.8656E-18 M=1.0
C7682 GD 687  65.9682E-18 M=1.0
C7683 GD 686  326.322E-18 M=1.0
C7684 GD 685  799.4889E-18 M=1.0
C7685 GD 684  66.4299E-18 M=1.0
C7686 GD 641  66.4299E-18 M=1.0
C7687 GD 640  31.6845E-18 M=1.0
C7688 GD 638  65.9682E-18 M=1.0
C7689 GD 637  326.322E-18 M=1.0
C7690 GD 636  799.4889E-18 M=1.0
C7691 GD 635  66.4299E-18 M=1.0
C7692 GD 590  3.38799735E-15 M=1.0
C7693 GD 582  674.3988E-18 M=1.0
C7694 GD 538  623.8467E-18 M=1.0
C7695 GD 533  674.3988E-18 M=1.0
C7696 VD 893  66.4299E-18 M=1.0
C7697 VD 892  65.9682E-18 M=1.0
C7698 VD 891  66.4299E-18 M=1.0
C7699 VD 695  689.1111E-18 M=1.0
C7700 VD 590  2.16545265E-15 M=1.0
C7701 695 891  76.9572E-18 M=1.0
C7702 689 893  76.2687E-18 M=1.0
C7703 640 892  52.3044E-18 M=1.0
C7704 640 695  348.39225E-18 M=1.0
C7705 640 685  52.3044E-18 M=1.0
C7706 639 687  73.7334E-18 M=1.0
C7707 639 686  56.8818E-18 M=1.0
C7708 639 685  56.8818E-18 M=1.0
C7709 639 640  107.5266E-18 M=1.0
C7710 637 640  553.2183E-18 M=1.0
C7711 636 640  56.3148E-18 M=1.0
C7712 582 640  77.796E-18 M=1.0
C7713 582 636  56.8818E-18 M=1.0
C7714 582 635  74.025E-18 M=1.0
C7715 582 590  56.8818E-18 M=1.0
C7716 538 640  67.5702E-18 M=1.0
C7717 538 635  56.8818E-18 M=1.0
C7718 533 695  324.4266E-18 M=1.0
C7719 533 685  230.61645E-18 M=1.0
C7720 533 684  52.3044E-18 M=1.0
C7721 533 640  315.6687E-18 M=1.0
C7722 533 639  282.6234E-18 M=1.0
C7723 533 636  52.3044E-18 M=1.0
C7724 533 590  52.3044E-18 M=1.0
C7725 533 582  52.3044E-18 M=1.0
C7726 533 538  52.3044E-18 M=1.0
C7727 477 892  104.241375E-18 M=1.0
C7728 477 695  52.3044E-18 M=1.0
C7729 477 637  51.74415E-18 M=1.0
C7730 477 636  80.5347E-18 M=1.0
C7731 477 582  323.246925E-18 M=1.0
C7732 477 538  52.3044E-18 M=1.0
C7733 477 533  69.7005E-18 M=1.0
C7734 GD 689  461.630475E-18 M=1.0
C7735 GD 640  811.0989E-18 M=1.0
C7736 GD 639  2.65479525E-15 M=1.0
C7737 GD 582  5.852688075E-15 M=1.0
C7738 VD 689  153.123075E-18 M=1.0
C7739 VD 533  304.964775E-18 M=1.0
C7740 VD 477  266.62725E-18 M=1.0
C7741 533 582  127.4634E-18 M=1.0
C7742 GD 793  91.1411999999995E-18 M=1.0
C7743 GD 792  76.2128999999999E-18 M=1.0
C7744 GD 791  70.713E-18 M=1.0
C7745 GD 790  91.1411999999997E-18 M=1.0
C7746 GD 789  76.2128999999999E-18 M=1.0
C7747 GD 788  70.713E-18 M=1.0
C7748 GD 787  91.1412000000001E-18 M=1.0
C7749 GD 688  84.0699000000001E-18 M=1.0
C7750 GD 645  84.0699000000001E-18 M=1.0
C7751 791 792  171.7443E-18 M=1.0
C7752 788 789  171.7443E-18 M=1.0
C7753 723 791  75.2328E-18 M=1.0
C7754 723 788  75.2328E-18 M=1.0
C7755 688 788  75.2328E-18 M=1.0
C7756 645 791  75.2328E-18 M=1.0
C7757 GD 793  202.6413E-18 M=1.0
C7758 GD 792  226.8738E-18 M=1.0
C7759 GD 791  250.7832E-18 M=1.0
C7760 GD 790  202.6413E-18 M=1.0
C7761 GD 789  226.8738E-18 M=1.0
C7762 GD 788  250.7832E-18 M=1.0
C7763 GD 723  364.0581E-18 M=1.0
C7764 GD 688  174.8907E-18 M=1.0
C7765 GD S_11  183.8277E-18 M=1.0
C7766 GD S_10  183.8277E-18 M=1.0
C7767 S_9 GD  183.8277E-18 M=1.0
C7768 VD 793  30.4272E-18 M=1.0
C7769 VD 792  30.4272E-18 M=1.0
C7770 VD 791  45.4923E-18 M=1.0
C7771 VD 790  30.4272E-18 M=1.0
C7772 VD 789  30.4272E-18 M=1.0
C7773 VD 788  45.4923E-18 M=1.0
C7774 VD 723  33.4611E-18 M=1.0
C7775 VD 645  50.8401E-18 M=1.0
C7776 VD S_11  30.4272E-18 M=1.0
C7777 VD S_10  30.4272E-18 M=1.0
C7778 VD S_9  30.4272E-18 M=1.0
C7779 723 792  74.9664E-18 M=1.0
C7780 723 791  117.0432E-18 M=1.0
C7781 723 789  74.9664E-18 M=1.0
C7782 723 788  117.0432E-18 M=1.0
C7783 688 723  42.0768E-18 M=1.0
C7784 645 723  42.0768E-18 M=1.0
C7785 723 793  69.741E-18 M=1.0
C7786 723 791  51.7365E-18 M=1.0
C7787 723 790  69.741E-18 M=1.0
C7788 723 789  62.8848E-18 M=1.0
C7789 723 788  121.7691E-18 M=1.0
C7790 723 787  69.741E-18 M=1.0
C7791 688 723  25.6374E-18 M=1.0
C7792 669 721  61.5321E-18 M=1.0
C7793 645 791  44.1036E-18 M=1.0
C7794 645 790  121.945275E-18 M=1.0
C7795 645 723  79.0254E-18 M=1.0
C7796 645 721  81.9837E-18 M=1.0
C7797 S_11 723  44.1036E-18 M=1.0
C7798 S_10 723  44.1036E-18 M=1.0
C7799 S_10 645  44.1036E-18 M=1.0
C7800 GD 688  1.81913445E-15 M=1.0
C7801 S_9 723  44.1036E-18 M=1.0
C7802 VD 723  303.53085E-18 M=1.0
C7803 VD 688  1.0933533E-15 M=1.0
C7804 VD 645  828.395775E-18 M=1.0
C7805 GD 784  91.1412E-18 M=1.0
C7806 GD 783  76.2128999999995E-18 M=1.0
C7807 GD 782  70.7130000000003E-18 M=1.0
C7808 GD 694  84.0699000000001E-18 M=1.0
C7809 782 783  171.7443E-18 M=1.0
C7810 722 782  75.2328E-18 M=1.0
C7811 694 782  75.2328E-18 M=1.0
C7812 GD 785  250.7832E-18 M=1.0
C7813 GD 784  202.6413E-18 M=1.0
C7814 GD 783  226.8738E-18 M=1.0
C7815 GD 782  250.7832E-18 M=1.0
C7816 GD 694  174.8907E-18 M=1.0
C7817 S_8 GD  183.8277E-18 M=1.0
C7818 S_7 GD  183.8277E-18 M=1.0
C7819 VD 785  45.4923E-18 M=1.0
C7820 VD 784  30.4272E-18 M=1.0
C7821 VD 783  30.4272E-18 M=1.0
C7822 VD 782  45.4923E-18 M=1.0
C7823 VD 694  50.8401E-18 M=1.0
C7824 VD S_8  30.4272E-18 M=1.0
C7825 722 783  74.9664E-18 M=1.0
C7826 722 782  117.0432E-18 M=1.0
C7827 694 722  42.0768E-18 M=1.0
C7828 639 723  42.0768E-18 M=1.0
C7829 GD 722  1.2803967E-15 M=1.0
C7830 S_8 GD  34.33095E-18 M=1.0
C7831 723 785  51.7365E-18 M=1.0
C7832 722 784  69.741E-18 M=1.0
C7833 722 782  44.1036E-18 M=1.0
C7834 694 782  44.1036E-18 M=1.0
C7835 694 722  51.2748E-18 M=1.0
C7836 688 721  61.5321E-18 M=1.0
C7837 639 785  44.1036E-18 M=1.0
C7838 639 723  51.2748E-18 M=1.0
C7839 639 721  61.5321E-18 M=1.0
C7840 S_8 722  44.1036E-18 M=1.0
C7841 GD 742  91.1412000000005E-18 M=1.0
C7842 GD 741  84.0699000000005E-18 M=1.0
C7843 GD 716  23.5710000000001E-18 M=1.0
C7844 GD 704  84.0699000000005E-18 M=1.0
C7845 GD 652  209.781900000001E-18 M=1.0
C7846 GD 627  248.2812E-18 M=1.0
C7847 GD 613  91.1411999999998E-18 M=1.0
C7848 GD 607  31.8208499999995E-18 M=1.0
C7849 GD 606  469.062899999999E-18 M=1.0
C7850 GD 603  76.2129000000001E-18 M=1.0
C7851 GD 597  69.9272999999999E-18 M=1.0
C7852 GD 593  94.2839999999994E-18 M=1.0
C7853 GD 589  70.7130000000005E-18 M=1.0
C7854 GD 587  69.9272999999999E-18 M=1.0
C7855 GD 570  113.9265E-18 M=1.0
C7856 GD 569  91.1411999999997E-18 M=1.0
C7857 GD 568  69.9273000000001E-18 M=1.0
C7858 GD 565  91.1411999999998E-18 M=1.0
C7859 GD 562  69.9273000000001E-18 M=1.0
C7860 GD 559  76.2129E-18 M=1.0
C7861 GD 552  76.2129000000001E-18 M=1.0
C7862 GD 550  204.282E-18 M=1.0
C7863 GD 549  204.282E-18 M=1.0
C7864 GD 548  254.5668E-18 M=1.0
C7865 GD 547  70.7129999999996E-18 M=1.0
C7866 GD 542  29.8565999999999E-18 M=1.0
C7867 GD 524  23.5710000000002E-18 M=1.0
C7868 GD 490  139.8546E-18 M=1.0
C7869 GD 487  139.8546E-18 M=1.0
C7870 GD 388  593.989199999996E-18 M=1.0
C7871 GD 328  69.9272999999993E-18 M=1.0
C7872 GD 327  69.927300000001E-18 M=1.0
C7873 GD 141  282.852E-18 M=1.0
C7874 GD 109  209.7819E-18 M=1.0
C7875 GD 34  282.852E-18 M=1.0
C7876 GD 3  254.5668E-18 M=1.0
C7877 VD 653  40.0707000000003E-18 M=1.0
C7878 VD 652  40.0706999999996E-18 M=1.0
C7879 VD 627  40.0706999999997E-18 M=1.0
C7880 VD 607  32.6065500000004E-18 M=1.0
C7881 VD 570  33.7851E-18 M=1.0
C7882 VD 550  74.6414999999999E-18 M=1.0
C7883 VD 488  26.7137999999998E-18 M=1.0
C7884 VD 388  106.8552E-18 M=1.0
C7885 VD 141  53.4275999999995E-18 M=1.0
C7886 VD 34  53.4276000000004E-18 M=1.0
C7887 VD 3  81.7127999999996E-18 M=1.0
C7888 CLK GD  195.6393E-18 M=1.0
C7889 CLK VD  100.5696E-18 M=1.0
C7890 CLK_EN GD  23.5710000000002E-18 M=1.0
C7891 CLK_EN VD  36.9278999999999E-18 M=1.0
C7892 745 770  75.2328E-18 M=1.0
C7893 741 770  75.2327999999998E-18 M=1.0
C7894 611 627  75.2327999999999E-18 M=1.0
C7895 589 704  75.2328E-18 M=1.0
C7896 589 603  171.7443E-18 M=1.0
C7897 570 607  75.2328E-18 M=1.0
C7898 555 593  66.57525E-18 M=1.0
C7899 550 594  454.8447E-18 M=1.0
C7900 549 609  454.8447E-18 M=1.0
C7901 547 619  75.2328E-18 M=1.0
C7902 547 606  75.2328E-18 M=1.0
C7903 547 559  171.7443E-18 M=1.0
C7904 542 566  75.2328E-18 M=1.0
C7905 539 594  75.2328E-18 M=1.0
C7906 539 552  171.7443E-18 M=1.0
C7907 524 542  75.2328E-18 M=1.0
C7908 491 540  75.2328E-18 M=1.0
C7909 440 498  75.2328E-18 M=1.0
C7910 388 589  75.2328E-18 M=1.0
C7911 388 539  75.2328E-18 M=1.0
C7912 388 491  75.2328E-18 M=1.0
C7913 388 440  75.2328E-18 M=1.0
C7914 244 326  454.8447E-18 M=1.0
C7915 GD 742  202.6413E-18 M=1.0
C7916 GD 741  194.3694E-18 M=1.0
C7917 GD 704  174.8907E-18 M=1.0
C7918 GD 653  239.9328E-18 M=1.0
C7919 GD 652  239.9328E-18 M=1.0
C7920 GD 627  239.9328E-18 M=1.0
C7921 GD 619  174.8907E-18 M=1.0
C7922 GD 618  183.8277E-18 M=1.0
C7923 GD 613  202.6413E-18 M=1.0
C7924 GD 611  219.5424E-18 M=1.0
C7925 GD 609  181.134E-18 M=1.0
C7926 GD 607  78.5412E-18 M=1.0
C7927 GD 603  226.8738E-18 M=1.0
C7928 GD 597  189.5436E-18 M=1.0
C7929 GD 594  191.6757E-18 M=1.0
C7930 GD 589  250.7832E-18 M=1.0
C7931 GD 587  189.5436E-18 M=1.0
C7932 GD 573  44.0136000000004E-18 M=1.0
C7933 GD 572  44.0136000000003E-18 M=1.0
C7934 GD 569  202.6413E-18 M=1.0
C7935 GD 568  189.5436E-18 M=1.0
C7936 GD 566  114.5304E-18 M=1.0
C7937 GD 565  202.6413E-18 M=1.0
C7938 GD 562  189.5436E-18 M=1.0
C7939 GD 559  226.8738E-18 M=1.0
C7940 GD 552  226.8738E-18 M=1.0
C7941 GD 542  259.7859E-18 M=1.0
C7942 GD 540  174.8907E-18 M=1.0
C7943 GD 539  250.7832E-18 M=1.0
C7944 GD 524  77.2551E-18 M=1.0
C7945 GD 500  226.8738E-18 M=1.0
C7946 GD 491  250.7832E-18 M=1.0
C7947 GD 490  214.7382E-18 M=1.0
C7948 GD 487  214.7382E-18 M=1.0
C7949 GD 472  259.4115E-18 M=1.0
C7950 GD 440  250.7832E-18 M=1.0
C7951 GD 388  364.211999999999E-18 M=1.0
C7952 GD 327  189.5436E-18 M=1.0
C7953 GD 326  181.133999999999E-18 M=1.0
C7954 VD 770  45.4923000000003E-18 M=1.0
C7955 VD 742  30.4272000000001E-18 M=1.0
C7956 VD 741  50.8401000000001E-18 M=1.0
C7957 VD 619  50.8401000000001E-18 M=1.0
C7958 VD 613  30.4272000000001E-18 M=1.0
C7959 VD 611  67.8456000000003E-18 M=1.0
C7960 VD 607  56.0232E-18 M=1.0
C7961 VD 606  42.1506000000001E-18 M=1.0
C7962 VD 603  30.4272000000001E-18 M=1.0
C7963 VD 599  30.4272000000001E-18 M=1.0
C7964 VD 598  30.4271999999998E-18 M=1.0
C7965 VD 597  30.4271999999999E-18 M=1.0
C7966 VD 594  50.8401000000001E-18 M=1.0
C7967 VD 589  45.4923E-18 M=1.0
C7968 VD 588  30.4272000000001E-18 M=1.0
C7969 VD 587  30.4271999999999E-18 M=1.0
C7970 VD 571  30.4272000000001E-18 M=1.0
C7971 VD 569  30.4272000000001E-18 M=1.0
C7972 VD 568  30.4272000000001E-18 M=1.0
C7973 VD 566  68.4612E-18 M=1.0
C7974 VD 565  30.4272000000001E-18 M=1.0
C7975 VD 562  30.4272000000001E-18 M=1.0
C7976 VD 560  30.4272E-18 M=1.0
C7977 VD 559  30.4272000000001E-18 M=1.0
C7978 VD 558  30.4271999999999E-18 M=1.0
C7979 VD 557  30.4272000000001E-18 M=1.0
C7980 VD 556  30.4271999999998E-18 M=1.0
C7981 VD 555  44.7722999999999E-18 M=1.0
C7982 VD 552  30.4272000000001E-18 M=1.0
C7983 VD 550  106.011E-18 M=1.0
C7984 VD 548  102.8232E-18 M=1.0
C7985 VD 540  50.8401E-18 M=1.0
C7986 VD 539  45.4923E-18 M=1.0
C7987 VD 524  54.6434999999999E-18 M=1.0
C7988 VD 523  30.4272000000001E-18 M=1.0
C7989 VD 509  30.4272000000001E-18 M=1.0
C7990 VD 500  30.4272000000001E-18 M=1.0
C7991 VD 498  50.8401E-18 M=1.0
C7992 VD 491  45.4923E-18 M=1.0
C7993 VD 472  30.4272000000001E-18 M=1.0
C7994 VD 461  30.4272000000001E-18 M=1.0
C7995 VD 452  30.4272000000001E-18 M=1.0
C7996 VD 440  45.4923E-18 M=1.0
C7997 VD 388  30.4272000000001E-18 M=1.0
C7998 VD 327  30.4272000000001E-18 M=1.0
C7999 VD 279  30.4271999999999E-18 M=1.0
C8000 CLK 570  75.2328E-18 M=1.0
C8001 CLK GD  111.08925E-18 M=1.0
C8002 CLK VD  32.1363E-18 M=1.0
C8003 CLK_EN GD  676.675350000001E-18 M=1.0
C8004 CLK_EN VD  58.83165E-18 M=1.0
C8005 741 770  179.1504E-18 M=1.0
C8006 741 745  80.604E-18 M=1.0
C8007 653 883  34.9776E-18 M=1.0
C8008 652 880  34.9776E-18 M=1.0
C8009 627 881  34.9776E-18 M=1.0
C8010 609 883  68.7384000000001E-18 M=1.0
C8011 609 653  127.7451E-18 M=1.0
C8012 599 880  69.2000999999999E-18 M=1.0
C8013 599 652  139.9104E-18 M=1.0
C8014 598 879  69.2000999999999E-18 M=1.0
C8015 597 883  34.9776E-18 M=1.0
C8016 597 653  100.0224E-18 M=1.0
C8017 594 881  68.7384E-18 M=1.0
C8018 594 627  127.7451E-18 M=1.0
C8019 588 606  65.0448E-18 M=1.0
C8020 587 883  34.9776E-18 M=1.0
C8021 587 653  69.9552E-18 M=1.0
C8022 587 597  100.0224E-18 M=1.0
C8023 573 652  34.9776E-18 M=1.0
C8024 573 599  69.2001E-18 M=1.0
C8025 572 598  69.2001E-18 M=1.0
C8026 570 593  186.5898E-18 M=1.0
C8027 569 606  100.0224E-18 M=1.0
C8028 568 881  34.9776E-18 M=1.0
C8029 568 627  100.0224E-18 M=1.0
C8030 562 881  34.9776E-18 M=1.0
C8031 562 627  69.9552E-18 M=1.0
C8032 562 568  100.0224E-18 M=1.0
C8033 559 606  74.9664E-18 M=1.0
C8034 555 593  96.6348E-18 M=1.0
C8035 550 881  34.9776E-18 M=1.0
C8036 550 627  104.9328E-18 M=1.0
C8037 550 594  65.0448000000001E-18 M=1.0
C8038 550 568  100.0224E-18 M=1.0
C8039 550 562  100.0224E-18 M=1.0
C8040 549 883  34.9776E-18 M=1.0
C8041 549 609  65.0448000000001E-18 M=1.0
C8042 549 597  100.0224E-18 M=1.0
C8043 549 587  100.0224E-18 M=1.0
C8044 548 880  69.9552E-18 M=1.0
C8045 548 652  139.9104E-18 M=1.0
C8046 548 573  69.9552E-18 M=1.0
C8047 547 606  182.088E-18 M=1.0
C8048 388 704  77.0544E-18 M=1.0
C8049 388 603  74.9664E-18 M=1.0
C8050 388 589  182.088E-18 M=1.0
C8051 388 571  65.0448E-18 M=1.0
C8052 388 565  100.0224E-18 M=1.0
C8053 388 552  74.9664E-18 M=1.0
C8054 388 539  182.088E-18 M=1.0
C8055 328 846  34.9776E-18 M=1.0
C8056 327 846  34.9776E-18 M=1.0
C8057 327 328  100.0224E-18 M=1.0
C8058 244 846  34.9776E-18 M=1.0
C8059 244 328  100.0224E-18 M=1.0
C8060 244 327  100.0224E-18 M=1.0
C8061 141 880  34.9776E-18 M=1.0
C8062 141 652  174.888E-18 M=1.0
C8063 141 573  34.9776E-18 M=1.0
C8064 141 548  174.888E-18 M=1.0
C8065 109 879  34.9776E-18 M=1.0
C8066 109 572  34.9776E-18 M=1.0
C8067 101 327  100.0224E-18 M=1.0
C8068 34 879  34.9776E-18 M=1.0
C8069 34 598  204.9552E-18 M=1.0
C8070 34 572  34.9776E-18 M=1.0
C8071 34 109  174.888E-18 M=1.0
C8072 3 879  69.9552E-18 M=1.0
C8073 3 598  169.9776E-18 M=1.0
C8074 3 572  69.9552E-18 M=1.0
C8075 3 109  139.9104E-18 M=1.0
C8076 3 34  174.888E-18 M=1.0
C8077 GD 741  180.4824E-18 M=1.0
C8078 GD 627  456.8508E-18 M=1.0
C8079 GD 599  799.488900000001E-18 M=1.0
C8080 GD 598  799.4889E-18 M=1.0
C8081 GD 597  146.8449E-18 M=1.0
C8082 GD 587  230.8167E-18 M=1.0
C8083 GD 573  66.4299E-18 M=1.0
C8084 GD 572  66.4299E-18 M=1.0
C8085 GD 568  146.8449E-18 M=1.0
C8086 GD 562  230.8167E-18 M=1.0
C8087 GD 498  21.0987E-18 M=1.0
C8088 GD 472  407.538E-18 M=1.0
C8089 GD 327  146.8449E-18 M=1.0
C8090 GD 109  13.9338036E-15 M=1.0
C8091 GD 101  7.4923416E-15 M=1.0
C8092 S_3 GD  31.6845E-18 M=1.0
C8093 VD 883  65.9682E-18 M=1.0
C8094 VD 881  65.9681999999999E-18 M=1.0
C8095 VD 880  66.4299E-18 M=1.0
C8096 VD 879  66.4299000000001E-18 M=1.0
C8097 VD 846  65.9682E-18 M=1.0
C8098 VD 741  348.4404E-18 M=1.0
C8099 VD 594  21.0987E-18 M=1.0
C8100 VD 593  635.82975E-18 M=1.0
C8101 VD 550  527.5539E-18 M=1.0
C8102 VD 549  527.5539E-18 M=1.0
C8103 VD 540  21.0987E-18 M=1.0
C8104 VD 451  209.6163E-18 M=1.0
C8105 VD 388  221.6745E-18 M=1.0
C8106 VD 244  527.5539E-18 M=1.0
C8107 VD 3  689.1111E-18 M=1.0
C8108 CLK 566  34.9776E-18 M=1.0
C8109 CLK 560  79.35615E-18 M=1.0
C8110 CLK_EN 593  95.1993E-18 M=1.0
C8111 745 770  54.3294E-18 M=1.0
C8112 741 745  25.6374E-18 M=1.0
C8113 719 742  69.741E-18 M=1.0
C8114 719 741  67.9203E-18 M=1.0
C8115 655 742  69.741E-18 M=1.0
C8116 655 741  44.1036E-18 M=1.0
C8117 652 880  52.6203000000001E-18 M=1.0
C8118 627 881  52.9098750000001E-18 M=1.0
C8119 627 704  53.813025E-18 M=1.0
C8120 627 653  180.8514E-18 M=1.0
C8121 619 627  117.5238E-18 M=1.0
C8122 611 704  60.0345E-18 M=1.0
C8123 611 619  190.0224E-18 M=1.0
C8124 609 653  30.5316E-18 M=1.0
C8125 609 627  84.225825E-18 M=1.0
C8126 606 618  56.8817999999999E-18 M=1.0
C8127 599 653  217.0773E-18 M=1.0
C8128 597 627  77.9418E-18 M=1.0
C8129 594 627  257.47515E-18 M=1.0
C8130 594 619  68.7942E-18 M=1.0
C8131 588 606  56.8817999999999E-18 M=1.0
C8132 587 627  107.4321E-18 M=1.0
C8133 582 607  102.7701E-18 M=1.0
C8134 582 593  161.2107E-18 M=1.0
C8135 573 653  52.3044E-18 M=1.0
C8136 572 652  52.3044E-18 M=1.0
C8137 570 582  47.3742E-18 M=1.0
C8138 568 627  40.78665E-18 M=1.0
C8139 568 619  69.741E-18 M=1.0
C8140 568 594  56.9223E-18 M=1.0
C8141 562 619  145.476E-18 M=1.0
C8142 562 594  129.3777E-18 M=1.0
C8143 552 619  88.2072E-18 M=1.0
C8144 550 704  25.6374E-18 M=1.0
C8145 550 627  500.8482E-18 M=1.0
C8146 550 619  51.2748E-18 M=1.0
C8147 550 594  33.2703E-18 M=1.0
C8148 549 653  52.3044E-18 M=1.0
C8149 549 609  59.1993E-18 M=1.0
C8150 549 573  70.614E-18 M=1.0
C8151 549 557  88.2072E-18 M=1.0
C8152 548 880  52.6203000000001E-18 M=1.0
C8153 548 652  52.3044E-18 M=1.0
C8154 548 572  52.3044E-18 M=1.0
C8155 548 556  88.2072E-18 M=1.0
C8156 539 619  86.13495E-18 M=1.0
C8157 523 540  44.1036E-18 M=1.0
C8158 509 540  69.741E-18 M=1.0
C8159 500 540  69.741E-18 M=1.0
C8160 490 550  118.854E-18 M=1.0
C8161 489 606  1.52265195E-15 M=1.0
C8162 489 569  20.4516E-18 M=1.0
C8163 489 559  25.3224E-18 M=1.0
C8164 487 548  116.5779E-18 M=1.0
C8165 472 619  25.6374E-18 M=1.0
C8166 472 588  141.147E-18 M=1.0
C8167 472 569  121.2282E-18 M=1.0
C8168 472 559  114.8985E-18 M=1.0
C8169 472 500  130.5207E-18 M=1.0
C8170 472 491  211.437E-18 M=1.0
C8171 461 498  44.1036E-18 M=1.0
C8172 452 498  69.741E-18 M=1.0
C8173 435 451  104.6088E-18 M=1.0
C8174 388 619  61.4592E-18 M=1.0
C8175 388 571  56.8817999999999E-18 M=1.0
C8176 388 540  25.6374E-18 M=1.0
C8177 388 498  25.6374E-18 M=1.0
C8178 388 472  122.9184E-18 M=1.0
C8179 388 435  52.3044E-18 M=1.0
C8180 324 327  62.1081E-18 M=1.0
C8181 249 327  60.0345E-18 M=1.0
C8182 249 326  34.5024E-18 M=1.0
C8183 244 338  104.6088E-18 M=1.0
C8184 244 324  121.5837E-18 M=1.0
C8185 244 249  76.9122E-18 M=1.0
C8186 141 880  52.3044000000001E-18 M=1.0
C8187 141 652  52.3044E-18 M=1.0
C8188 141 572  52.3044E-18 M=1.0
C8189 141 548  52.3044E-18 M=1.0
C8190 109 879  52.6203E-18 M=1.0
C8191 101 326  51.2748E-18 M=1.0
C8192 101 324  121.5837E-18 M=1.0
C8193 101 249  76.9122E-18 M=1.0
C8194 34 879  52.3044E-18 M=1.0
C8195 34 141  106.0173E-18 M=1.0
C8196 34 109  104.6088E-18 M=1.0
C8197 3 879  52.6203E-18 M=1.0
C8198 3 548  46.3806E-18 M=1.0
C8199 3 141  51.2748E-18 M=1.0
C8200 3 109  104.6088E-18 M=1.0
C8201 3 34  104.6088E-18 M=1.0
C8202 3 33  52.3044E-18 M=1.0
C8203 GD 719  1.5326451E-15 M=1.0
C8204 GD 653  866.12355E-18 M=1.0
C8205 GD 627  934.42905E-18 M=1.0
C8206 GD 619  1.5218874E-15 M=1.0
C8207 GD 618  650.8053E-18 M=1.0
C8208 GD 571  1.44545895E-15 M=1.0
C8209 GD 550  302.251275E-18 M=1.0
C8210 GD 549  605.574E-18 M=1.0
C8211 GD 548  639.0693E-18 M=1.0
C8212 VD 704  149.9661E-18 M=1.0
C8213 VD 652  519.67485E-18 M=1.0
C8214 VD 627  240.765975E-18 M=1.0
C8215 VD 619  532.77975E-18 M=1.0
C8216 VD 594  145.14345E-18 M=1.0
C8217 VD 558  670.887675E-18 M=1.0
C8218 VD 557  511.02045E-18 M=1.0
C8219 VD 550  183.41595E-18 M=1.0
C8220 VD 549  154.79595E-18 M=1.0
C8221 VD 548  140.2596E-18 M=1.0
C8222 VD 498  1.1945502E-15 M=1.0
C8223 VD 141  201.672E-18 M=1.0
C8224 VD 109  164.0043E-18 M=1.0
C8225 VD 34  267.514875E-18 M=1.0
C8226 VD 3  278.7633E-18 M=1.0
C8227 CLK 593  52.3044E-18 M=1.0
C8228 CLK 582  176.0256E-18 M=1.0
C8229 CLK 570  147.99915E-18 M=1.0
C8230 CLK 560  25.6374E-18 M=1.0
C8231 CLK GD  245.4498E-18 M=1.0
C8232 CLK VD  332.15175E-18 M=1.0
C8233 CLK_EN 582  192.179925E-18 M=1.0
C8234 537 588  46.9206E-18 M=1.0
C8235 537 569  117.9495E-18 M=1.0
C8236 537 559  156.122325E-18 M=1.0
C8237 537 547  70.0875E-18 M=1.0
C8238 533 607  64.755E-18 M=1.0
C8239 533 570  269.134875E-18 M=1.0
C8240 533 560  179.99685E-18 M=1.0
C8241 523 619  86.8986E-18 M=1.0
C8242 523 606  104.323725E-18 M=1.0
C8243 523 569  70.371E-18 M=1.0
C8244 523 559  70.371E-18 M=1.0
C8245 477 570  43.77555E-18 M=1.0
C8246 477 560  64.7955E-18 M=1.0
C8247 328 329  36.486E-18 M=1.0
C8248 327 329  36.486E-18 M=1.0
C8249 326 329  84.7629E-18 M=1.0
C8250 324 329  640.314E-18 M=1.0
C8251 GD 533  1.609002E-15 M=1.0
C8252 GD 477  1.55415285E-15 M=1.0
C8253 GD 329  1.956267E-15 M=1.0
C8254 CLK_EN 533  43.7148E-18 M=1.0
C8255 GD 555  172.068299999999E-18 M=1.0
C8256 GD 498  84.0699000000005E-18 M=1.0
C8257 GD 451  70.7130000000006E-18 M=1.0
C8258 GD 446  70.7129999999996E-18 M=1.0
C8259 GD 440  70.7130000000005E-18 M=1.0
C8260 GD 435  84.0698999999997E-18 M=1.0
C8261 GD 416  91.1412000000003E-18 M=1.0
C8262 GD 414  70.713E-18 M=1.0
C8263 GD 413  76.2128999999998E-18 M=1.0
C8264 GD 412  91.1412000000003E-18 M=1.0
C8265 GD 410  70.7130000000001E-18 M=1.0
C8266 GD 409  76.2129E-18 M=1.0
C8267 GD 408  91.1411999999999E-18 M=1.0
C8268 GD 406  70.7129999999998E-18 M=1.0
C8269 GD 405  76.2128999999996E-18 M=1.0
C8270 GD 404  91.1412000000005E-18 M=1.0
C8271 GD 387  593.989199999999E-18 M=1.0
C8272 GD 339  70.7130000000004E-18 M=1.0
C8273 GD 255  254.566800000002E-18 M=1.0
C8274 GD 222  282.852000000001E-18 M=1.0
C8275 A_6 GD  84.0699000000005E-18 M=1.0
C8276 VD 555  63.6417000000003E-18 M=1.0
C8277 VD 451  110.7837E-18 M=1.0
C8278 VD 255  81.7128000000003E-18 M=1.0
C8279 B_2 GD  84.0698999999988E-18 M=1.0
C8280 B_1 GD  84.0698999999997E-18 M=1.0
C8281 B_0 GD  84.0699000000005E-18 M=1.0
C8282 496 555  75.2328E-18 M=1.0
C8283 440 452  171.7443E-18 M=1.0
C8284 435 446  75.2328E-18 M=1.0
C8285 413 414  171.7443E-18 M=1.0
C8286 409 410  171.7443E-18 M=1.0
C8287 405 406  171.7443E-18 M=1.0
C8288 387 414  75.2328E-18 M=1.0
C8289 387 410  75.2328E-18 M=1.0
C8290 387 406  75.2328E-18 M=1.0
C8291 339 369  75.2328E-18 M=1.0
C8292 339 340  171.7443E-18 M=1.0
C8293 292 496  75.2328E-18 M=1.0
C8294 GD 555  146.63925E-18 M=1.0
C8295 GD 519  202.6413E-18 M=1.0
C8296 GD 496  250.7832E-18 M=1.0
C8297 GD 456  189.5436E-18 M=1.0
C8298 GD 452  226.8738E-18 M=1.0
C8299 GD 451  125.5887E-18 M=1.0
C8300 GD 446  250.7832E-18 M=1.0
C8301 GD 414  250.7832E-18 M=1.0
C8302 GD 413  226.8738E-18 M=1.0
C8303 GD 412  202.6413E-18 M=1.0
C8304 GD 410  250.7832E-18 M=1.0
C8305 GD 409  226.8738E-18 M=1.0
C8306 GD 408  202.6413E-18 M=1.0
C8307 GD 406  250.783200000001E-18 M=1.0
C8308 GD 405  226.8738E-18 M=1.0
C8309 GD 404  202.6413E-18 M=1.0
C8310 GD 339  250.7832E-18 M=1.0
C8311 GD 296  44.0136E-18 M=1.0
C8312 GD 292  174.8907E-18 M=1.0
C8313 A_6 339  75.2327999999999E-18 M=1.0
C8314 VD 538  80.8164E-18 M=1.0
C8315 VD 519  30.4271999999999E-18 M=1.0
C8316 VD 504  30.4271999999999E-18 M=1.0
C8317 VD 456  30.4272E-18 M=1.0
C8318 VD 455  30.4272E-18 M=1.0
C8319 VD 446  45.4923E-18 M=1.0
C8320 VD 444  30.4272E-18 M=1.0
C8321 VD 443  30.4272E-18 M=1.0
C8322 VD 415  30.4272E-18 M=1.0
C8323 VD 414  45.4922999999999E-18 M=1.0
C8324 VD 413  30.4271999999999E-18 M=1.0
C8325 VD 412  30.4272000000001E-18 M=1.0
C8326 VD 411  30.4271999999999E-18 M=1.0
C8327 VD 410  45.4923000000001E-18 M=1.0
C8328 VD 409  30.4271999999999E-18 M=1.0
C8329 VD 408  30.4272000000001E-18 M=1.0
C8330 VD 407  30.4272000000001E-18 M=1.0
C8331 VD 406  45.4923000000001E-18 M=1.0
C8332 VD 405  30.4272000000001E-18 M=1.0
C8333 VD 404  30.4271999999999E-18 M=1.0
C8334 VD 403  30.4271999999999E-18 M=1.0
C8335 VD 387  30.4272000000001E-18 M=1.0
C8336 VD 340  30.4272000000001E-18 M=1.0
C8337 VD 339  45.4923000000001E-18 M=1.0
C8338 VD 292  50.8401000000001E-18 M=1.0
C8339 VD A_6  20.4129E-18 M=1.0
C8340 B_2 414  75.2327999999999E-18 M=1.0
C8341 B_2 VD  20.4129E-18 M=1.0
C8342 B_1 410  75.2327999999999E-18 M=1.0
C8343 B_1 VD  20.4129E-18 M=1.0
C8344 B_0 406  75.2327999999999E-18 M=1.0
C8345 B_0 VD  20.4129E-18 M=1.0
C8346 538 582  209.8656E-18 M=1.0
C8347 538 555  97.8426E-18 M=1.0
C8348 519 555  177.192E-18 M=1.0
C8349 504 555  246.1194E-18 M=1.0
C8350 496 555  196.9704E-18 M=1.0
C8351 443 582  69.9552E-18 M=1.0
C8352 435 606  69.8256E-18 M=1.0
C8353 388 498  77.0544E-18 M=1.0
C8354 388 440  182.088E-18 M=1.0
C8355 387 414  117.0432E-18 M=1.0
C8356 387 413  74.9664E-18 M=1.0
C8357 387 410  117.0432E-18 M=1.0
C8358 387 409  74.9664E-18 M=1.0
C8359 387 406  117.0432E-18 M=1.0
C8360 387 405  74.9664E-18 M=1.0
C8361 339 369  117.0432E-18 M=1.0
C8362 292 555  87.7032E-18 M=1.0
C8363 222 297  204.9552E-18 M=1.0
C8364 222 255  174.888E-18 M=1.0
C8365 222 248  174.888E-18 M=1.0
C8366 GD 555  1.31640795E-15 M=1.0
C8367 GD 435  21.0987E-18 M=1.0
C8368 GD 387  1.2803238E-15 M=1.0
C8369 A_6 369  42.0768E-18 M=1.0
C8370 VD 555  336.9708E-18 M=1.0
C8371 B_2 387  42.0768E-18 M=1.0
C8372 B_1 387  42.0768E-18 M=1.0
C8373 B_0 387  87.5088E-18 M=1.0
C8374 555 582  451.829925E-18 M=1.0
C8375 538 582  96.408E-18 M=1.0
C8376 538 555  82.8243E-18 M=1.0
C8377 519 582  69.741E-18 M=1.0
C8378 519 538  69.741E-18 M=1.0
C8379 504 538  44.1036E-18 M=1.0
C8380 496 582  54.3294E-18 M=1.0
C8381 496 538  200.493225E-18 M=1.0
C8382 447 451  60.8031000000001E-18 M=1.0
C8383 440 447  372.3345E-18 M=1.0
C8384 435 606  25.6374E-18 M=1.0
C8385 435 446  44.1036E-18 M=1.0
C8386 404 435  25.6374E-18 M=1.0
C8387 403 435  44.2089E-18 M=1.0
C8388 388 447  52.3044E-18 M=1.0
C8389 299 415  96.7239E-18 M=1.0
C8390 299 414  66.94515E-18 M=1.0
C8391 299 387  76.9122E-18 M=1.0
C8392 298 415  96.408E-18 M=1.0
C8393 298 414  44.1036E-18 M=1.0
C8394 298 413  170.6454E-18 M=1.0
C8395 298 387  102.5496E-18 M=1.0
C8396 293 415  70.614E-18 M=1.0
C8397 293 414  211.437E-18 M=1.0
C8398 293 413  44.1036E-18 M=1.0
C8399 293 412  69.741E-18 M=1.0
C8400 293 411  70.614E-18 M=1.0
C8401 293 410  211.437E-18 M=1.0
C8402 293 409  44.1036E-18 M=1.0
C8403 293 408  69.741E-18 M=1.0
C8404 293 407  122.9184E-18 M=1.0
C8405 293 406  211.437E-18 M=1.0
C8406 293 405  111.822975E-18 M=1.0
C8407 292 606  76.9122E-18 M=1.0
C8408 292 582  25.6374E-18 M=1.0
C8409 292 451  52.3044E-18 M=1.0
C8410 292 446  70.399125E-18 M=1.0
C8411 292 435  25.6374E-18 M=1.0
C8412 292 406  25.6374E-18 M=1.0
C8413 292 405  44.1036E-18 M=1.0
C8414 292 404  44.1036E-18 M=1.0
C8415 292 387  119.5335E-18 M=1.0
C8416 248 837  52.6203E-18 M=1.0
C8417 248 255  52.3044E-18 M=1.0
C8418 222 248  52.3044E-18 M=1.0
C8419 GD 538  4.80660165E-15 M=1.0
C8420 GD 298  1.97832195E-15 M=1.0
C8421 GD 293  3.114079425E-15 M=1.0
C8422 VD 582  629.823825E-18 M=1.0
C8423 VD 538  668.918250000001E-18 M=1.0
C8424 VD 435  162.1485E-18 M=1.0
C8425 VD 298  463.44735E-18 M=1.0
C8426 VD 292  448.0065E-18 M=1.0
C8427 B_2 299  25.6374E-18 M=1.0
C8428 B_2 298  64.2735E-18 M=1.0
C8429 456 477  64.9575E-18 M=1.0
C8430 444 477  64.9575E-18 M=1.0
C8431 387 416  64.755E-18 M=1.0
C8432 387 415  43.7148E-18 M=1.0
C8433 387 414  43.7148E-18 M=1.0
C8434 387 412  64.755E-18 M=1.0
C8435 387 411  43.7148E-18 M=1.0
C8436 387 410  43.7148E-18 M=1.0
C8437 387 408  64.755E-18 M=1.0
C8438 387 407  43.7148E-18 M=1.0
C8439 387 406  43.7148E-18 M=1.0
C8440 387 404  64.755E-18 M=1.0
C8441 387 403  43.7148E-18 M=1.0
C8442 339 369  43.7148E-18 M=1.0
C8443 297 329  703.365975E-18 M=1.0
C8444 292 387  58.6386E-18 M=1.0
C8445 255 329  95.6106E-18 M=1.0
C8446 248 329  137.7333E-18 M=1.0
C8447 222 329  56.93445E-18 M=1.0
C8448 GD 387  760.9356E-18 M=1.0
C8449 GD 369  704.4192E-18 M=1.0
C8450 A_6 369  21.0402E-18 M=1.0
C8451 VD 387  120.4029E-18 M=1.0
C8452 B_2 387  21.0402E-18 M=1.0
C8453 B_1 387  21.0402E-18 M=1.0
C8454 GD 345  91.1412000000004E-18 M=1.0
C8455 GD 344  76.2129000000003E-18 M=1.0
C8456 GD 343  70.713E-18 M=1.0
C8457 GD 341  91.1412000000003E-18 M=1.0
C8458 GD 340  76.2129000000006E-18 M=1.0
C8459 GD 303  139.8546E-18 M=1.0
C8460 GD 301  69.9273000000005E-18 M=1.0
C8461 GD 248  209.781900000001E-18 M=1.0
C8462 A_5 GD  84.0698999999997E-18 M=1.0
C8463 A_4 GD  84.0698999999997E-18 M=1.0
C8464 VD 369  106.8552E-18 M=1.0
C8465 VD 303  26.7138000000001E-18 M=1.0
C8466 VD 254  40.0707E-18 M=1.0
C8467 VD 248  40.0706999999998E-18 M=1.0
C8468 343 369  75.2328E-18 M=1.0
C8469 343 344  171.7443E-18 M=1.0
C8470 GD 369  364.212E-18 M=1.0
C8471 GD 347  250.7832E-18 M=1.0
C8472 GD 345  202.6413E-18 M=1.0
C8473 GD 344  226.8738E-18 M=1.0
C8474 GD 343  250.7832E-18 M=1.0
C8475 GD 341  202.6413E-18 M=1.0
C8476 GD 340  226.8738E-18 M=1.0
C8477 GD 303  214.7382E-18 M=1.0
C8478 GD 300  44.0136E-18 M=1.0
C8479 GD 297  214.7382E-18 M=1.0
C8480 GD 261  236.745E-18 M=1.0
C8481 A_5 343  75.2327999999999E-18 M=1.0
C8482 VD 347  45.4923E-18 M=1.0
C8483 VD 345  30.4272000000001E-18 M=1.0
C8484 VD 344  30.4271999999999E-18 M=1.0
C8485 VD 343  45.4923E-18 M=1.0
C8486 VD 341  30.4271999999999E-18 M=1.0
C8487 VD 299  50.8401000000001E-18 M=1.0
C8488 VD 297  30.4271999999999E-18 M=1.0
C8489 VD A_5  20.4129E-18 M=1.0
C8490 344 369  74.9664E-18 M=1.0
C8491 343 369  117.0432E-18 M=1.0
C8492 340 369  74.9664E-18 M=1.0
C8493 317 838  34.9776E-18 M=1.0
C8494 303 317  169.9776E-18 M=1.0
C8495 301 317  100.0224E-18 M=1.0
C8496 301 303  135E-18 M=1.0
C8497 300 317  34.9776E-18 M=1.0
C8498 299 303  65.0448E-18 M=1.0
C8499 297 837  69.2001E-18 M=1.0
C8500 296 297  69.2001E-18 M=1.0
C8501 261 301  100.0224E-18 M=1.0
C8502 255 837  69.9552E-18 M=1.0
C8503 255 296  69.9552E-18 M=1.0
C8504 254 838  34.9776E-18 M=1.0
C8505 254 303  139.9104E-18 M=1.0
C8506 254 301  100.0224E-18 M=1.0
C8507 254 300  34.9776E-18 M=1.0
C8508 254 261  174.888E-18 M=1.0
C8509 248 837  34.9776E-18 M=1.0
C8510 248 297  139.9104E-18 M=1.0
C8511 248 296  34.9776E-18 M=1.0
C8512 248 255  139.9104E-18 M=1.0
C8513 222 837  34.9776E-18 M=1.0
C8514 222 296  34.9776E-18 M=1.0
C8515 GD 369  1.2735E-15 M=1.0
C8516 GD 303  799.4889E-18 M=1.0
C8517 GD 301  326.322E-18 M=1.0
C8518 GD 300  65.9682E-18 M=1.0
C8519 GD 296  66.4299E-18 M=1.0
C8520 GD 254  397.0251E-18 M=1.0
C8521 A_5 369  42.0768E-18 M=1.0
C8522 A_4 369  42.0768E-18 M=1.0
C8523 VD 838  65.9682E-18 M=1.0
C8524 VD 837  66.4299E-18 M=1.0
C8525 VD 411  847.0548E-18 M=1.0
C8526 VD 255  689.1111E-18 M=1.0
C8527 299 369  174.1842E-18 M=1.0
C8528 299 346  52.3044E-18 M=1.0
C8529 299 345  172.8216E-18 M=1.0
C8530 299 303  52.3044E-18 M=1.0
C8531 298 369  262.12905E-18 M=1.0
C8532 298 346  52.3044E-18 M=1.0
C8533 298 344  250.8021E-18 M=1.0
C8534 298 343  44.1036E-18 M=1.0
C8535 255 342  52.3044E-18 M=1.0
C8536 204 837  168.16185E-18 M=1.0
C8537 204 296  52.3044E-18 M=1.0
C8538 GD 329  267.85035E-18 M=1.0
C8539 GD 299  1.589774175E-15 M=1.0
C8540 GD 255  666.59715E-18 M=1.0
C8541 GD 222  231.99795E-18 M=1.0
C8542 VD 329  138.0843E-18 M=1.0
C8543 VD 255  298.6803E-18 M=1.0
C8544 369 415  49.5477E-18 M=1.0
C8545 369 411  49.5477E-18 M=1.0
C8546 347 369  43.7148E-18 M=1.0
C8547 346 369  74.2464E-18 M=1.0
C8548 345 369  64.755E-18 M=1.0
C8549 343 369  43.7148E-18 M=1.0
C8550 342 369  68.23575E-18 M=1.0
C8551 341 369  64.755E-18 M=1.0
C8552 299 369  58.6386E-18 M=1.0
C8553 298 369  58.6386E-18 M=1.0
C8554 222 411  49.5477E-18 M=1.0
C8555 222 342  49.5477E-18 M=1.0
C8556 204 222  200.6145E-18 M=1.0
C8557 A_5 369  21.0402E-18 M=1.0
C8558 A_4 369  21.0402E-18 M=1.0
C8559 VD 329  386.5626E-18 M=1.0
C8560 VD 222  24.6987E-18 M=1.0
C8561 GD 369  593.989199999997E-18 M=1.0
C8562 GD 337  91.1412000000003E-18 M=1.0
C8563 GD 336  76.2128999999998E-18 M=1.0
C8564 GD 335  70.7130000000004E-18 M=1.0
C8565 GD 297  139.854600000001E-18 M=1.0
C8566 GD 295  69.9273000000001E-18 M=1.0
C8567 GD 244  204.281999999999E-18 M=1.0
C8568 A_7 GD  84.0699000000005E-18 M=1.0
C8569 VD 297  26.7137999999998E-18 M=1.0
C8570 VD 222  53.4276E-18 M=1.0
C8571 335 369  75.2328E-18 M=1.0
C8572 335 336  171.7443E-18 M=1.0
C8573 GD 337  202.6413E-18 M=1.0
C8574 GD 336  226.8738E-18 M=1.0
C8575 GD 335  250.783199999999E-18 M=1.0
C8576 GD 328  189.5436E-18 M=1.0
C8577 GD 295  189.5436E-18 M=1.0
C8578 GD 294  44.0136E-18 M=1.0
C8579 GD 293  174.8907E-18 M=1.0
C8580 GD 248  239.9328E-18 M=1.0
C8581 GD 222  236.745E-18 M=1.0
C8582 A_7 335  75.2327999999999E-18 M=1.0
C8583 VD 451  73.4625E-18 M=1.0
C8584 VD 369  30.4272000000001E-18 M=1.0
C8585 VD 337  30.4271999999999E-18 M=1.0
C8586 VD 336  30.4271999999999E-18 M=1.0
C8587 VD 335  45.4923000000001E-18 M=1.0
C8588 VD 328  30.4271999999998E-18 M=1.0
C8589 VD 295  30.4271999999999E-18 M=1.0
C8590 VD A_7  20.4129E-18 M=1.0
C8591 338 369  34.4592E-18 M=1.0
C8592 336 369  74.9664E-18 M=1.0
C8593 335 369  117.0432E-18 M=1.0
C8594 295 297  135E-18 M=1.0
C8595 293 297  65.0448E-18 M=1.0
C8596 255 836  34.9776E-18 M=1.0
C8597 255 297  169.9776E-18 M=1.0
C8598 255 295  100.0224E-18 M=1.0
C8599 255 294  34.9776E-18 M=1.0
C8600 248 836  34.9776E-18 M=1.0
C8601 248 295  100.0224E-18 M=1.0
C8602 248 294  34.9776E-18 M=1.0
C8603 222 295  100.0224E-18 M=1.0
C8604 101 328  69.9552E-18 M=1.0
C8605 101 244  104.9328E-18 M=1.0
C8606 GD 451  3.5461377E-15 M=1.0
C8607 GD 328  230.8167E-18 M=1.0
C8608 GD 297  799.4889E-18 M=1.0
C8609 GD 295  326.322E-18 M=1.0
C8610 GD 294  65.9682E-18 M=1.0
C8611 GD 248  397.0251E-18 M=1.0
C8612 GD 222  623.8467E-18 M=1.0
C8613 A_7 369  42.0768E-18 M=1.0
C8614 A_7 338  20.7792E-18 M=1.0
C8615 VD 836  65.9682E-18 M=1.0
C8616 VD 407  680.859E-18 M=1.0
C8617 324 338  453.2049E-18 M=1.0
C8618 324 328  62.1081E-18 M=1.0
C8619 293 369  61.4592E-18 M=1.0
C8620 293 338  52.3044E-18 M=1.0
C8621 293 336  216.9252E-18 M=1.0
C8622 293 335  44.1036E-18 M=1.0
C8623 293 297  52.3044E-18 M=1.0
C8624 292 407  52.3044E-18 M=1.0
C8625 292 369  249.2478E-18 M=1.0
C8626 292 338  52.3044E-18 M=1.0
C8627 292 335  103.846275E-18 M=1.0
C8628 279 324  41.7807E-18 M=1.0
C8629 249 407  448.9461E-18 M=1.0
C8630 249 338  52.3044E-18 M=1.0
C8631 249 328  239.242725E-18 M=1.0
C8632 204 407  52.3044E-18 M=1.0
C8633 204 338  52.3044E-18 M=1.0
C8634 204 297  77.9418E-18 M=1.0
C8635 204 295  77.9418E-18 M=1.0
C8636 204 293  44.814375E-18 M=1.0
C8637 204 292  44.814375E-18 M=1.0
C8638 204 222  277.85745E-18 M=1.0
C8639 GD 324  1.356223275E-15 M=1.0
C8640 GD 292  2.04495975E-15 M=1.0
C8641 GD 249  2.3643675E-15 M=1.0
C8642 GD 244  1.07466705E-15 M=1.0
C8643 A_7 292  25.6374E-18 M=1.0
C8644 VD 244  154.79595E-18 M=1.0
C8645 369 407  49.5477E-18 M=1.0
C8646 369 403  49.5477E-18 M=1.0
C8647 338 369  65.0664E-18 M=1.0
C8648 337 369  64.755E-18 M=1.0
C8649 335 369  43.7148E-18 M=1.0
C8650 329 407  49.5477E-18 M=1.0
C8651 295 329  43.0425E-18 M=1.0
C8652 293 369  58.6386E-18 M=1.0
C8653 293 329  69.53085E-18 M=1.0
C8654 292 369  58.6386E-18 M=1.0
C8655 292 329  74.1573E-18 M=1.0
C8656 249 329  58.6386000000001E-18 M=1.0
C8657 244 329  63.219825E-18 M=1.0
C8658 204 329  117.2772E-18 M=1.0
C8659 A_7 369  21.0402E-18 M=1.0
C8660 GD 566  73.0701E-18 M=1.0
C8661 GD 525  29.8566E-18 M=1.0
C8662 GD 519  91.1411999999997E-18 M=1.0
C8663 GD 510  31.8208500000001E-18 M=1.0
C8664 GD 504  76.2129E-18 M=1.0
C8665 GD 496  70.713E-18 M=1.0
C8666 GD 465  23.571E-18 M=1.0
C8667 GD 456  69.9273000000001E-18 M=1.0
C8668 GD 455  69.9273000000001E-18 M=1.0
C8669 GD 443  69.9273000000001E-18 M=1.0
C8670 GD 292  84.0699000000001E-18 M=1.0
C8671 VD 524  36.9279000000002E-18 M=1.0
C8672 VD 511  32.6065499999999E-18 M=1.0
C8673 VD 510  32.6065499999999E-18 M=1.0
C8674 VD 466  36.9279E-18 M=1.0
C8675 VD 465  36.9279E-18 M=1.0
C8676 510 525  75.2328E-18 M=1.0
C8677 496 504  171.7443E-18 M=1.0
C8678 467 511  75.2328E-18 M=1.0
C8679 466 477  454.8447E-18 M=1.0
C8680 465 538  454.8447E-18 M=1.0
C8681 465 525  75.2328E-18 M=1.0
C8682 GD 525  136.6038E-18 M=1.0
C8683 GD 511  78.5411999999999E-18 M=1.0
C8684 GD 510  78.5412E-18 M=1.0
C8685 GD 504  226.8738E-18 M=1.0
C8686 GD 466  197.7435E-18 M=1.0
C8687 GD 465  197.7435E-18 M=1.0
C8688 GD 455  189.5436E-18 M=1.0
C8689 GD 443  189.5436E-18 M=1.0
C8690 VD 525  34.2306E-18 M=1.0
C8691 VD 511  56.0232E-18 M=1.0
C8692 VD 510  56.0232E-18 M=1.0
C8693 VD 477  80.8164E-18 M=1.0
C8694 VD 466  50.8401E-18 M=1.0
C8695 VD 465  50.8401E-18 M=1.0
C8696 582 864  34.9776E-18 M=1.0
C8697 538 864  34.9776E-18 M=1.0
C8698 533 865  34.9776E-18 M=1.0
C8699 477 865  34.9776E-18 M=1.0
C8700 466 865  68.2767E-18 M=1.0
C8701 466 533  127.7451E-18 M=1.0
C8702 465 864  68.2767E-18 M=1.0
C8703 465 582  127.7451E-18 M=1.0
C8704 456 865  34.9776E-18 M=1.0
C8705 456 533  100.0224E-18 M=1.0
C8706 456 477  100.0224E-18 M=1.0
C8707 455 864  34.9776E-18 M=1.0
C8708 455 582  100.0224E-18 M=1.0
C8709 455 538  100.0224E-18 M=1.0
C8710 444 865  34.9776E-18 M=1.0
C8711 444 477  100.0224E-18 M=1.0
C8712 444 456  100.0224E-18 M=1.0
C8713 443 864  34.9776E-18 M=1.0
C8714 443 538  100.0224E-18 M=1.0
C8715 443 455  100.0224E-18 M=1.0
C8716 GD 456  157.7223E-18 M=1.0
C8717 GD 455  157.7223E-18 M=1.0
C8718 GD 443  236.2554E-18 M=1.0
C8719 VD 865  65.9682E-18 M=1.0
C8720 VD 864  65.9682E-18 M=1.0
C8721 VD 538  379.7613E-18 M=1.0
C8722 VD 477  348.0768E-18 M=1.0
C8723 524 525  28.040175E-18 M=1.0
C8724 510 525  54.0657E-18 M=1.0
C8725 466 533  25.6374E-18 M=1.0
C8726 465 582  25.6374E-18 M=1.0
C8727 465 525  23.0445E-18 M=1.0
C8728 GD 566  634.3551E-18 M=1.0
C8729 GD 542  908.84745E-18 M=1.0
C8730 GD 525  632.1105E-18 M=1.0
C8731 GD 524  186.3144E-18 M=1.0
C8732 GD 466  374.05035E-18 M=1.0
C8733 GD 465  412.42095E-18 M=1.0
C8734 VD 566  667.266525E-18 M=1.0
C8735 VD 542  383.58675E-18 M=1.0
C8736 VD 525  164.9079E-18 M=1.0
C8737 VD 524  335.16495E-18 M=1.0
C8738 VD 466  86.68395E-18 M=1.0
C8739 VD 465  278.3628E-18 M=1.0
C8740 CLK 566  56.8818E-18 M=1.0
C8741 533 566  74.2518E-18 M=1.0
C8742 533 542  63.7317E-18 M=1.0
C8743 525 533  74.496375E-18 M=1.0
C8744 511 533  48.807E-18 M=1.0
C8745 477 566  74.2518E-18 M=1.0
C8746 477 542  63.7317E-18 M=1.0
C8747 477 525  63.7317E-18 M=1.0
C8748 467 533  21.0402E-18 M=1.0
C8749 466 533  36.486E-18 M=1.0
C8750 466 477  45.1323E-18 M=1.0
C8751 456 533  21.7125E-18 M=1.0
C8752 VD 533  420.0921E-18 M=1.0
C8753 CLK 533  33.18975E-18 M=1.0
C8754 CLK 477  33.18975E-18 M=1.0
C8755 GD 619  84.0698999999997E-18 M=1.0
C8756 GD 594  84.0699000000005E-18 M=1.0
C8757 GD 540  84.0699000000005E-18 M=1.0
C8758 GD 539  70.7130000000005E-18 M=1.0
C8759 GD 518  91.1411999999997E-18 M=1.0
C8760 GD 509  91.1411999999998E-18 M=1.0
C8761 GD 503  76.2129E-18 M=1.0
C8762 GD 500  76.2129000000001E-18 M=1.0
C8763 GD 495  70.7129999999996E-18 M=1.0
C8764 GD 491  70.7130000000005E-18 M=1.0
C8765 GD 471  91.1411999999997E-18 M=1.0
C8766 GD 461  91.1411999999998E-18 M=1.0
C8767 GD 458  76.2129E-18 M=1.0
C8768 GD 452  76.2129000000001E-18 M=1.0
C8769 GD 447  84.0698999999997E-18 M=1.0
C8770 VD 606  117.0693E-18 M=1.0
C8771 495 606  75.2328E-18 M=1.0
C8772 495 503  171.7443E-18 M=1.0
C8773 491 500  171.7443E-18 M=1.0
C8774 447 495  75.2328E-18 M=1.0
C8775 446 606  75.2328E-18 M=1.0
C8776 446 458  171.7443E-18 M=1.0
C8777 GD 606  311.78925E-18 M=1.0
C8778 GD 547  250.7832E-18 M=1.0
C8779 GD 518  202.6413E-18 M=1.0
C8780 GD 509  202.6413E-18 M=1.0
C8781 GD 503  226.8738E-18 M=1.0
C8782 GD 495  250.7832E-18 M=1.0
C8783 GD 471  202.6413E-18 M=1.0
C8784 GD 461  202.6413E-18 M=1.0
C8785 GD 458  226.8738E-18 M=1.0
C8786 VD 547  45.4923E-18 M=1.0
C8787 VD 537  30.4272000000001E-18 M=1.0
C8788 VD 518  30.4272000000001E-18 M=1.0
C8789 VD 503  30.4272000000001E-18 M=1.0
C8790 VD 496  45.4923E-18 M=1.0
C8791 VD 495  45.4923E-18 M=1.0
C8792 VD 489  30.4272000000001E-18 M=1.0
C8793 VD 471  30.4272000000001E-18 M=1.0
C8794 VD 458  30.4272000000001E-18 M=1.0
C8795 606 619  77.0544E-18 M=1.0
C8796 537 606  65.0448E-18 M=1.0
C8797 518 606  100.0224E-18 M=1.0
C8798 503 606  74.9664E-18 M=1.0
C8799 495 606  182.088E-18 M=1.0
C8800 489 606  65.0448E-18 M=1.0
C8801 471 606  100.0224E-18 M=1.0
C8802 458 606  74.9664E-18 M=1.0
C8803 447 606  77.0544E-18 M=1.0
C8804 446 606  117.0432E-18 M=1.0
C8805 388 594  77.0544E-18 M=1.0
C8806 388 540  77.0544E-18 M=1.0
C8807 388 523  65.0448E-18 M=1.0
C8808 388 509  100.0224E-18 M=1.0
C8809 388 500  74.9664E-18 M=1.0
C8810 388 491  182.088E-18 M=1.0
C8811 388 472  65.0448E-18 M=1.0
C8812 388 461  100.0224E-18 M=1.0
C8813 388 452  74.9664E-18 M=1.0
C8814 GD 606  6.48476775E-15 M=1.0
C8815 GD 388  2.804499E-15 M=1.0
C8816 489 547  44.0046E-18 M=1.0
C8817 489 537  85.4748E-18 M=1.0
C8818 489 518  46.5975E-18 M=1.0
C8819 489 503  25.3224E-18 M=1.0
C8820 489 495  44.0046E-18 M=1.0
C8821 472 606  153.1332E-18 M=1.0
C8822 472 547  44.1036E-18 M=1.0
C8823 472 537  66.2607E-18 M=1.0
C8824 472 518  121.2282E-18 M=1.0
C8825 472 503  243.590175E-18 M=1.0
C8826 292 495  44.761725E-18 M=1.0
C8827 292 489  44.36685E-18 M=1.0
C8828 292 471  70.135875E-18 M=1.0
C8829 292 458  70.00425E-18 M=1.0
C8830 292 447  25.6374E-18 M=1.0
C8831 GD 489  2.907263925E-15 M=1.0
C8832 GD 472  2.50512075E-15 M=1.0
C8833 VD 447  1.42363485E-15 M=1.0
C8834 537 619  23.1669E-18 M=1.0
C8835 537 606  125.930025E-18 M=1.0
C8836 523 547  69.517125E-18 M=1.0
C8837 523 537  47.2041E-18 M=1.0
C8838 518 523  23.1669E-18 M=1.0
C8839 388 523  49.5477E-18 M=1.0
C8840 GD 537  1.7883297E-15 M=1.0
C8841 VD 523  1.14612435E-15 M=1.0
C8842 GD 488  139.8546E-18 M=1.0
C8843 GD 450  209.781900000001E-18 M=1.0
C8844 GD 448  209.7819E-18 M=1.0
C8845 GD 392  69.9273E-18 M=1.0
C8846 GD 391  69.9272999999999E-18 M=1.0
C8847 GD 390  69.9273000000003E-18 M=1.0
C8848 GD 389  69.9272999999999E-18 M=1.0
C8849 GD 381  139.8546E-18 M=1.0
C8850 GD 380  139.8546E-18 M=1.0
C8851 GD 379  139.8546E-18 M=1.0
C8852 GD 378  139.8546E-18 M=1.0
C8853 GD 334  139.854600000004E-18 M=1.0
C8854 GD 323  282.852E-18 M=1.0
C8855 GD 288  282.852E-18 M=1.0
C8856 GD 249  254.5668E-18 M=1.0
C8857 GD 236  254.5668E-18 M=1.0
C8858 GD 204  282.852E-18 M=1.0
C8859 GD 143  254.566800000003E-18 M=1.0
C8860 GD 111  209.7819E-18 M=1.0
C8861 GD 36  282.852E-18 M=1.0
C8862 GD 5  254.566800000001E-18 M=1.0
C8863 VD 557  40.0707000000003E-18 M=1.0
C8864 VD 490  26.7138000000002E-18 M=1.0
C8865 VD 448  40.0707000000003E-18 M=1.0
C8866 VD 381  26.7138000000002E-18 M=1.0
C8867 VD 380  26.7138000000002E-18 M=1.0
C8868 VD 379  26.7137999999998E-18 M=1.0
C8869 VD 378  26.7138000000002E-18 M=1.0
C8870 VD 334  26.7138000000004E-18 M=1.0
C8871 VD 330  53.4276000000004E-18 M=1.0
C8872 VD 326  81.7128E-18 M=1.0
C8873 VD 323  53.4275999999995E-18 M=1.0
C8874 VD 283  53.4276000000004E-18 M=1.0
C8875 VD 249  81.7128000000006E-18 M=1.0
C8876 VD 204  53.4276000000004E-18 M=1.0
C8877 VD 111  40.0707000000003E-18 M=1.0
C8878 GD 516  44.0136000000004E-18 M=1.0
C8879 GD 463  44.0136000000004E-18 M=1.0
C8880 GD 450  239.9328E-18 M=1.0
C8881 GD 449  239.9328E-18 M=1.0
C8882 GD 447  174.8907E-18 M=1.0
C8883 GD 439  164.349E-18 M=1.0
C8884 GD 438  164.349E-18 M=1.0
C8885 GD 437  164.349E-18 M=1.0
C8886 GD 435  174.8907E-18 M=1.0
C8887 GD 399  44.0136000000003E-18 M=1.0
C8888 GD 398  44.0136000000006E-18 M=1.0
C8889 GD 397  44.0136000000004E-18 M=1.0
C8890 GD 396  44.0136E-18 M=1.0
C8891 GD 392  189.5436E-18 M=1.0
C8892 GD 391  189.5436E-18 M=1.0
C8893 GD 390  189.5436E-18 M=1.0
C8894 GD 389  189.5436E-18 M=1.0
C8895 GD 381  214.7382E-18 M=1.0
C8896 GD 380  214.7382E-18 M=1.0
C8897 GD 379  214.7382E-18 M=1.0
C8898 GD 378  214.7382E-18 M=1.0
C8899 GD 373  44.0136000000003E-18 M=1.0
C8900 GD 371  44.0136000000004E-18 M=1.0
C8901 GD 370  44.0136E-18 M=1.0
C8902 GD 332  189.543599999999E-18 M=1.0
C8903 GD 330  236.745000000001E-18 M=1.0
C8904 GD 323  236.745E-18 M=1.0
C8905 GD 204  236.745E-18 M=1.0
C8906 GD 36  133.0416E-18 M=1.0
C8907 VD 508  30.4271999999999E-18 M=1.0
C8908 VD 490  30.4271999999999E-18 M=1.0
C8909 VD 450  30.4271999999998E-18 M=1.0
C8910 VD 449  30.4271999999999E-18 M=1.0
C8911 VD 448  30.4272000000001E-18 M=1.0
C8912 VD 447  50.8401E-18 M=1.0
C8913 VD 435  50.8401E-18 M=1.0
C8914 VD 392  30.4271999999998E-18 M=1.0
C8915 VD 391  30.4271999999999E-18 M=1.0
C8916 VD 390  30.4272000000001E-18 M=1.0
C8917 VD 389  30.4271999999999E-18 M=1.0
C8918 VD 380  30.4271999999999E-18 M=1.0
C8919 VD 332  30.4272000000001E-18 M=1.0
C8920 VD 326  102.8232E-18 M=1.0
C8921 VD 245  102.823199999999E-18 M=1.0
C8922 557 876  34.9776E-18 M=1.0
C8923 557 869  34.9776E-18 M=1.0
C8924 516 556  34.9776E-18 M=1.0
C8925 490 869  69.2001E-18 M=1.0
C8926 463 556  34.9776E-18 M=1.0
C8927 463 488  69.2001E-18 M=1.0
C8928 450 859  34.9776E-18 M=1.0
C8929 449 858  34.9776E-18 M=1.0
C8930 448 860  34.9776E-18 M=1.0
C8931 448 852  34.9776E-18 M=1.0
C8932 439 516  34.9776E-18 M=1.0
C8933 439 463  69.9552E-18 M=1.0
C8934 437 876  34.9776E-18 M=1.0
C8935 437 869  69.9552E-18 M=1.0
C8936 398 448  34.9776E-18 M=1.0
C8937 397 450  34.9776E-18 M=1.0
C8938 396 449  34.9776E-18 M=1.0
C8939 391 448  100.0224E-18 M=1.0
C8940 390 450  100.0224E-18 M=1.0
C8941 389 449  100.0224E-18 M=1.0
C8942 381 439  65.0447999999999E-18 M=1.0
C8943 381 392  135E-18 M=1.0
C8944 380 852  69.2001E-18 M=1.0
C8945 380 448  139.9104E-18 M=1.0
C8946 380 438  65.0448E-18 M=1.0
C8947 380 391  135E-18 M=1.0
C8948 379 437  65.0448E-18 M=1.0
C8949 379 390  135E-18 M=1.0
C8950 378 449  139.9104E-18 M=1.0
C8951 378 435  65.0448000000001E-18 M=1.0
C8952 378 389  135E-18 M=1.0
C8953 371 450  34.9776E-18 M=1.0
C8954 371 379  69.2001E-18 M=1.0
C8955 332 334  135E-18 M=1.0
C8956 330 852  34.9776E-18 M=1.0
C8957 330 448  174.888E-18 M=1.0
C8958 330 391  100.0224E-18 M=1.0
C8959 330 380  204.9552E-18 M=1.0
C8960 326 860  34.9776E-18 M=1.0
C8961 326 852  69.9552E-18 M=1.0
C8962 326 398  34.9776E-18 M=1.0
C8963 326 391  100.0224E-18 M=1.0
C8964 326 380  169.9776E-18 M=1.0
C8965 326 330  174.888E-18 M=1.0
C8966 323 450  174.888E-18 M=1.0
C8967 323 390  100.0224E-18 M=1.0
C8968 323 379  204.9552E-18 M=1.0
C8969 323 371  34.9776E-18 M=1.0
C8970 288 463  34.9776E-18 M=1.0
C8971 283 869  34.9776E-18 M=1.0
C8972 249 858  34.9776E-18 M=1.0
C8973 249 449  139.9104E-18 M=1.0
C8974 249 396  34.9776E-18 M=1.0
C8975 249 389  100.0224E-18 M=1.0
C8976 249 378  169.9776E-18 M=1.0
C8977 245 334  169.9776E-18 M=1.0
C8978 245 282  139.9104E-18 M=1.0
C8979 236 859  34.9776E-18 M=1.0
C8980 236 450  139.9104E-18 M=1.0
C8981 236 397  34.9776E-18 M=1.0
C8982 236 390  100.0224E-18 M=1.0
C8983 236 379  169.9776E-18 M=1.0
C8984 236 371  69.9552E-18 M=1.0
C8985 236 323  174.888E-18 M=1.0
C8986 204 389  100.0224E-18 M=1.0
C8987 204 378  204.9552E-18 M=1.0
C8988 204 249  174.888E-18 M=1.0
C8989 133 287  139.9104E-18 M=1.0
C8990 111 861  34.9776E-18 M=1.0
C8991 111 853  34.9776E-18 M=1.0
C8992 111 399  34.9776E-18 M=1.0
C8993 111 392  100.0224E-18 M=1.0
C8994 111 381  139.9104E-18 M=1.0
C8995 111 373  34.9776E-18 M=1.0
C8996 36 392  100.0224E-18 M=1.0
C8997 36 381  204.9552E-18 M=1.0
C8998 36 111  174.888E-18 M=1.0
C8999 5 861  34.9776E-18 M=1.0
C9000 5 399  34.9776E-18 M=1.0
C9001 5 392  100.0224E-18 M=1.0
C9002 5 381  169.9776E-18 M=1.0
C9003 5 111  139.9104E-18 M=1.0
C9004 GD 516  65.9681999999999E-18 M=1.0
C9005 GD 463  66.4299E-18 M=1.0
C9006 GD 450  397.0251E-18 M=1.0
C9007 GD 449  397.0251E-18 M=1.0
C9008 GD 448  397.0251E-18 M=1.0
C9009 GD 399  65.9681999999999E-18 M=1.0
C9010 GD 398  65.9682000000001E-18 M=1.0
C9011 GD 397  65.9681999999999E-18 M=1.0
C9012 GD 396  65.9681999999999E-18 M=1.0
C9013 GD 392  326.322E-18 M=1.0
C9014 GD 391  326.322E-18 M=1.0
C9015 GD 390  326.322E-18 M=1.0
C9016 GD 389  326.322E-18 M=1.0
C9017 GD 380  799.4889E-18 M=1.0
C9018 GD 379  799.4889E-18 M=1.0
C9019 GD 378  799.4889E-18 M=1.0
C9020 GD 371  66.4299E-18 M=1.0
C9021 GD 330  623.8467E-18 M=1.0
C9022 GD 235  623.8467E-18 M=1.0
C9023 GD 204  623.8467E-18 M=1.0
C9024 GD 111  10.2572424E-15 M=1.0
C9025 VD 876  65.9682E-18 M=1.0
C9026 VD 869  66.4298999999999E-18 M=1.0
C9027 VD 861  65.9682E-18 M=1.0
C9028 VD 860  65.9682E-18 M=1.0
C9029 VD 859  65.9682E-18 M=1.0
C9030 VD 858  65.9682E-18 M=1.0
C9031 VD 852  66.4298999999999E-18 M=1.0
C9032 VD 326  689.1111E-18 M=1.0
C9033 VD 249  689.1111E-18 M=1.0
C9034 VD 236  689.1111E-18 M=1.0
C9035 557 869  69.6825E-18 M=1.0
C9036 463 557  69.7392E-18 M=1.0
C9037 450 851  52.6203000000001E-18 M=1.0
C9038 448 852  52.6203E-18 M=1.0
C9039 448 450  124.3224E-18 M=1.0
C9040 448 449  134.5482E-18 M=1.0
C9041 439 450  88.2072E-18 M=1.0
C9042 438 449  88.2072E-18 M=1.0
C9043 437 869  69.6825000000001E-18 M=1.0
C9044 437 463  52.3044E-18 M=1.0
C9045 437 448  88.2072E-18 M=1.0
C9046 437 439  46.3806E-18 M=1.0
C9047 435 447  71.933175E-18 M=1.0
C9048 392 450  122.0454E-18 M=1.0
C9049 391 449  122.0454E-18 M=1.0
C9050 390 448  264.33045E-18 M=1.0
C9051 389 435  77.9418E-18 M=1.0
C9052 381 450  144.4914E-18 M=1.0
C9053 381 439  116.5779E-18 M=1.0
C9054 380 449  144.4914E-18 M=1.0
C9055 380 438  118.854E-18 M=1.0
C9056 379 448  77.9418000000001E-18 M=1.0
C9057 379 437  116.5779E-18 M=1.0
C9058 378 447  165.5667E-18 M=1.0
C9059 378 435  52.3044E-18 M=1.0
C9060 373 450  52.3044E-18 M=1.0
C9061 371 448  52.3044E-18 M=1.0
C9062 330 852  52.3044E-18 M=1.0
C9063 330 449  129.2166E-18 M=1.0
C9064 330 448  52.3044E-18 M=1.0
C9065 330 334  125.0766E-18 M=1.0
C9066 330 332  26.5851E-18 M=1.0
C9067 326 449  208.9368E-18 M=1.0
C9068 326 448  52.3044E-18 M=1.0
C9069 323 450  52.3044E-18 M=1.0
C9070 323 448  129.2166E-18 M=1.0
C9071 288 861  221.25915E-18 M=1.0
C9072 288 450  39.40515E-18 M=1.0
C9073 288 439  97.82955E-18 M=1.0
C9074 288 392  303.476175E-18 M=1.0
C9075 283 860  223.848E-18 M=1.0
C9076 283 852  52.3044E-18 M=1.0
C9077 283 449  36.3451499999999E-18 M=1.0
C9078 283 448  113.805E-18 M=1.0
C9079 283 438  45.5251499999999E-18 M=1.0
C9080 283 391  72.5840999999999E-18 M=1.0
C9081 283 334  52.3044E-18 M=1.0
C9082 283 330  154.854E-18 M=1.0
C9083 283 287  67.716E-18 M=1.0
C9084 282 287  103.5792E-18 M=1.0
C9085 245 283  52.3044E-18 M=1.0
C9086 236 450  52.3044E-18 M=1.0
C9087 236 448  315.966599999999E-18 M=1.0
C9088 235 283  52.3044E-18 M=1.0
C9089 204 435  149.167125E-18 M=1.0
C9090 111 853  52.3044E-18 M=1.0
C9091 111 450  134.5482E-18 M=1.0
C9092 111 288  111.2121E-18 M=1.0
C9093 111 141  52.3044E-18 M=1.0
C9094 36 450  129.2166E-18 M=1.0
C9095 36 288  154.854E-18 M=1.0
C9096 5 450  213.4413E-18 M=1.0
C9097 5 288  136.8495E-18 M=1.0
C9098 GD 450  826.9263E-18 M=1.0
C9099 GD 449  838.4922E-18 M=1.0
C9100 GD 448  664.4619E-18 M=1.0
C9101 GD 447  535.466025E-18 M=1.0
C9102 GD 438  602.35605E-18 M=1.0
C9103 GD 435  1.552836375E-15 M=1.0
C9104 GD 330  907.139475E-18 M=1.0
C9105 GD 283  2.123403975E-15 M=1.0
C9106 GD 282  479.65635E-18 M=1.0
C9107 VD 450  522.086175E-18 M=1.0
C9108 VD 448  459.41805E-18 M=1.0
C9109 VD 437  121.5387E-18 M=1.0
C9110 VD 330  164.0043E-18 M=1.0
C9111 VD 283  917.361E-18 M=1.0
C9112 283 329  58.6386E-18 M=1.0
C9113 282 329  564.3648E-18 M=1.0
C9114 245 329  73.6406999999999E-18 M=1.0
C9115 GD 449  209.7819E-18 M=1.0
C9116 GD 330  282.851999999999E-18 M=1.0
C9117 GD 326  254.5668E-18 M=1.0
C9118 GD 325  64.4273999999999E-18 M=1.0
C9119 GD 245  254.566800000003E-18 M=1.0
C9120 GD 235  282.851999999996E-18 M=1.0
C9121 GD 165  282.851999999996E-18 M=1.0
C9122 GD 101  248.281200000001E-18 M=1.0
C9123 VD 449  40.0707000000003E-18 M=1.0
C9124 VD 325  33.7851E-18 M=1.0
C9125 VD 244  74.6415000000004E-18 M=1.0
C9126 VD 101  40.0706999999999E-18 M=1.0
C9127 101 325  75.2328E-18 M=1.0
C9128 GD 448  239.9328E-18 M=1.0
C9129 GD 372  44.0136000000006E-18 M=1.0
C9130 GD 333  44.0136E-18 M=1.0
C9131 GD 325  219.5424E-18 M=1.0
C9132 GD 286  44.0136E-18 M=1.0
C9133 GD 235  236.745E-18 M=1.0
C9134 GD 101  136.2294E-18 M=1.0
C9135 VD 378  30.4271999999999E-18 M=1.0
C9136 VD 334  30.4271999999998E-18 M=1.0
C9137 VD 325  67.8456000000001E-18 M=1.0
C9138 VD 324  30.4272000000001E-18 M=1.0
C9139 VD 278  30.4272000000001E-18 M=1.0
C9140 VD 244  106.011E-18 M=1.0
C9141 449 850  34.9776E-18 M=1.0
C9142 378 850  69.2000999999999E-18 M=1.0
C9143 372 448  34.9776E-18 M=1.0
C9144 372 380  69.2000999999999E-18 M=1.0
C9145 370 449  34.9776E-18 M=1.0
C9146 370 378  69.2000999999999E-18 M=1.0
C9147 334 848  69.2001000000001E-18 M=1.0
C9148 333 334  69.2001000000001E-18 M=1.0
C9149 330 372  34.9776E-18 M=1.0
C9150 326 846  68.7383999999999E-18 M=1.0
C9151 326 448  139.9104E-18 M=1.0
C9152 326 372  69.9552E-18 M=1.0
C9153 286 287  69.2001000000001E-18 M=1.0
C9154 282 848  34.9776E-18 M=1.0
C9155 282 334  139.9104E-18 M=1.0
C9156 282 333  34.9776E-18 M=1.0
C9157 249 850  69.9552E-18 M=1.0
C9158 249 370  69.9552E-18 M=1.0
C9159 245 848  69.9552000000001E-18 M=1.0
C9160 245 333  69.9552000000001E-18 M=1.0
C9161 244 326  65.0448E-18 M=1.0
C9162 235 848  34.9776E-18 M=1.0
C9163 235 334  204.9552E-18 M=1.0
C9164 235 333  34.9776E-18 M=1.0
C9165 235 282  174.888E-18 M=1.0
C9166 204 850  34.9776E-18 M=1.0
C9167 204 449  174.888E-18 M=1.0
C9168 204 370  34.9776E-18 M=1.0
C9169 165 287  204.9552E-18 M=1.0
C9170 165 286  34.9776E-18 M=1.0
C9171 143 286  69.9552000000001E-18 M=1.0
C9172 133 286  34.9776E-18 M=1.0
C9173 101 846  34.9776E-18 M=1.0
C9174 101 326  127.7451E-18 M=1.0
C9175 GD 372  66.4299000000001E-18 M=1.0
C9176 GD 370  66.4299E-18 M=1.0
C9177 GD 334  799.4889E-18 M=1.0
C9178 GD 333  66.4299000000001E-18 M=1.0
C9179 GD 286  66.4299000000001E-18 M=1.0
C9180 GD 282  397.0251E-18 M=1.0
C9181 VD 850  66.4298999999999E-18 M=1.0
C9182 VD 848  66.4299000000001E-18 M=1.0
C9183 449 850  52.6203E-18 M=1.0
C9184 372 449  52.3044E-18 M=1.0
C9185 326 403  52.3044E-18 M=1.0
C9186 326 334  263.9466E-18 M=1.0
C9187 326 330  52.3044E-18 M=1.0
C9188 325 326  69.741E-18 M=1.0
C9189 324 846  399.19095E-18 M=1.0
C9190 324 326  74.8026E-18 M=1.0
C9191 324 325  70.3728E-18 M=1.0
C9192 283 380  95.3784E-18 M=1.0
C9193 283 326  348.911325E-18 M=1.0
C9194 282 848  69.6825E-18 M=1.0
C9195 249 449  52.3044E-18 M=1.0
C9196 249 403  52.3044E-18 M=1.0
C9197 249 370  90.1476E-18 M=1.0
C9198 249 325  34.3971E-18 M=1.0
C9199 245 848  52.6203000000001E-18 M=1.0
C9200 245 403  52.3044E-18 M=1.0
C9201 245 326  51.2748E-18 M=1.0
C9202 245 286  52.3044000000001E-18 M=1.0
C9203 245 282  52.3044E-18 M=1.0
C9204 244 326  25.6374E-18 M=1.0
C9205 235 848  52.3044E-18 M=1.0
C9206 235 326  95.611725E-18 M=1.0
C9207 235 287  103.2642E-18 M=1.0
C9208 235 286  233.52705E-18 M=1.0
C9209 235 282  52.3044E-18 M=1.0
C9210 235 245  52.3044E-18 M=1.0
C9211 204 449  52.3044E-18 M=1.0
C9212 204 403  52.3044E-18 M=1.0
C9213 204 370  52.3044E-18 M=1.0
C9214 143 245  77.4954E-18 M=1.0
C9215 101 278  45.5251499999999E-18 M=1.0
C9216 GD 326  1.308103425E-15 M=1.0
C9217 GD 204  4.790352825E-15 M=1.0
C9218 VD 449  519.67485E-18 M=1.0
C9219 VD 326  112.869E-18 M=1.0
C9220 VD 282  618.15465E-18 M=1.0
C9221 VD 245  804.51E-18 M=1.0
C9222 VD 101  1.734725925E-15 M=1.0
C9223 329 403  49.5477E-18 M=1.0
C9224 325 329  64.755E-18 M=1.0
C9225 235 329  63.1206E-18 M=1.0
C9226 101 329  48.3471E-18 M=1.0
C9227 GD 332  69.9273000000016E-18 M=1.0
C9228 GD 290  64.4273999999999E-18 M=1.0
C9229 GD 287  139.854600000004E-18 M=1.0
C9230 GD 285  69.9273000000016E-18 M=1.0
C9231 GD 282  209.781900000003E-18 M=1.0
C9232 GD 280  69.9272999999999E-18 M=1.0
C9233 GD 246  69.9272999999999E-18 M=1.0
C9234 GD 164  248.281199999999E-18 M=1.0
C9235 GD 142  204.282E-18 M=1.0
C9236 VD 450  40.0706999999996E-18 M=1.0
C9237 VD 290  33.7850999999998E-18 M=1.0
C9238 VD 282  40.0706999999999E-18 M=1.0
C9239 VD 245  81.7128000000001E-18 M=1.0
C9240 VD 236  81.7128E-18 M=1.0
C9241 VD 235  53.4276E-18 M=1.0
C9242 VD 164  40.0706999999997E-18 M=1.0
C9243 VD 142  74.6414999999991E-18 M=1.0
C9244 VD 36  53.4276000000004E-18 M=1.0
C9245 VD 5  81.7127999999996E-18 M=1.0
C9246 164 290  75.2327999999999E-18 M=1.0
C9247 142 288  454.8447E-18 M=1.0
C9248 GD 334  214.738200000001E-18 M=1.0
C9249 GD 331  44.0135999999999E-18 M=1.0
C9250 GD 329  236.745E-18 M=1.0
C9251 GD 290  219.542399999999E-18 M=1.0
C9252 GD 287  214.738200000001E-18 M=1.0
C9253 GD 284  44.0135999999999E-18 M=1.0
C9254 GD 282  239.932799999999E-18 M=1.0
C9255 GD 280  189.5436E-18 M=1.0
C9256 GD 246  189.5436E-18 M=1.0
C9257 GD 111  136.2294E-18 M=1.0
C9258 VD 381  30.4271999999998E-18 M=1.0
C9259 VD 379  30.4272000000001E-18 M=1.0
C9260 VD 330  30.4271999999998E-18 M=1.0
C9261 VD 329  30.4272000000001E-18 M=1.0
C9262 VD 323  30.4272000000001E-18 M=1.0
C9263 VD 290  67.8456000000002E-18 M=1.0
C9264 VD 288  30.4272000000001E-18 M=1.0
C9265 VD 280  30.4272000000001E-18 M=1.0
C9266 VD 5  106.6266E-18 M=1.0
C9267 450 851  34.9776E-18 M=1.0
C9268 381 853  69.2000999999999E-18 M=1.0
C9269 379 851  69.2000999999999E-18 M=1.0
C9270 379 450  139.9104E-18 M=1.0
C9271 373 381  69.2001E-18 M=1.0
C9272 330 334  65.0448E-18 M=1.0
C9273 323 851  34.9776E-18 M=1.0
C9274 288 835  68.7383999999999E-18 M=1.0
C9275 285 287  135E-18 M=1.0
C9276 283 287  65.0448E-18 M=1.0
C9277 282 847  34.9776E-18 M=1.0
C9278 282 332  100.0224E-18 M=1.0
C9279 282 331  34.9776E-18 M=1.0
C9280 280 835  34.9776E-18 M=1.0
C9281 246 835  34.9776E-18 M=1.0
C9282 246 280  100.0224E-18 M=1.0
C9283 245 847  34.9776E-18 M=1.0
C9284 245 332  100.0224E-18 M=1.0
C9285 245 331  34.9776E-18 M=1.0
C9286 236 851  69.9552E-18 M=1.0
C9287 235 332  100.0224E-18 M=1.0
C9288 235 245  174.888E-18 M=1.0
C9289 165 285  100.0224E-18 M=1.0
C9290 164 835  34.9776E-18 M=1.0
C9291 164 288  127.7451E-18 M=1.0
C9292 164 280  100.0224E-18 M=1.0
C9293 164 246  69.9552E-18 M=1.0
C9294 143 287  169.9776E-18 M=1.0
C9295 143 285  100.0224E-18 M=1.0
C9296 143 284  34.9776E-18 M=1.0
C9297 142 835  34.9776E-18 M=1.0
C9298 142 288  65.0448000000001E-18 M=1.0
C9299 142 280  100.0224E-18 M=1.0
C9300 142 246  100.0224E-18 M=1.0
C9301 142 164  104.9328E-18 M=1.0
C9302 133 285  100.0224E-18 M=1.0
C9303 133 284  34.9776E-18 M=1.0
C9304 36 853  34.9776E-18 M=1.0
C9305 36 373  34.9776E-18 M=1.0
C9306 5 853  69.9552E-18 M=1.0
C9307 5 373  69.9552E-18 M=1.0
C9308 5 36  174.888E-18 M=1.0
C9309 GD 381  799.4889E-18 M=1.0
C9310 GD 373  66.4299E-18 M=1.0
C9311 GD 332  326.322E-18 M=1.0
C9312 GD 331  65.9682E-18 M=1.0
C9313 GD 323  623.8467E-18 M=1.0
C9314 GD 287  799.4889E-18 M=1.0
C9315 GD 285  326.322E-18 M=1.0
C9316 GD 284  65.9682E-18 M=1.0
C9317 GD 280  146.8449E-18 M=1.0
C9318 GD 246  230.8167E-18 M=1.0
C9319 GD 164  1.2833874E-15 M=1.0
C9320 VD 853  66.4299000000001E-18 M=1.0
C9321 VD 851  66.4299E-18 M=1.0
C9322 VD 847  65.9682E-18 M=1.0
C9323 VD 835  65.9681999999998E-18 M=1.0
C9324 VD 245  689.1111E-18 M=1.0
C9325 VD 142  527.5539E-18 M=1.0
C9326 VD 5  689.1111E-18 M=1.0
C9327 323 851  52.3044000000001E-18 M=1.0
C9328 323 373  52.3044E-18 M=1.0
C9329 288 381  95.3784E-18 M=1.0
C9330 288 323  44.1036E-18 M=1.0
C9331 288 290  69.741E-18 M=1.0
C9332 282 330  25.6374E-18 M=1.0
C9333 245 330  25.6374E-18 M=1.0
C9334 236 851  69.6825E-18 M=1.0
C9335 236 323  52.3044E-18 M=1.0
C9336 235 330  25.6374E-18 M=1.0
C9337 164 288  417.897900000001E-18 M=1.0
C9338 36 853  52.3044E-18 M=1.0
C9339 36 323  46.3806E-18 M=1.0
C9340 36 141  52.3044E-18 M=1.0
C9341 36 111  104.6088E-18 M=1.0
C9342 36 110  52.3044000000001E-18 M=1.0
C9343 36 109  52.3044E-18 M=1.0
C9344 5 853  69.6824999999999E-18 M=1.0
C9345 5 323  51.2748E-18 M=1.0
C9346 5 141  52.3044E-18 M=1.0
C9347 5 111  104.6088E-18 M=1.0
C9348 5 110  52.3044000000001E-18 M=1.0
C9349 5 109  52.3044E-18 M=1.0
C9350 5 36  104.6088E-18 M=1.0
C9351 5 35  52.3044E-18 M=1.0
C9352 5 34  52.3044E-18 M=1.0
C9353 5 33  52.3044E-18 M=1.0
C9354 GD 323  678.4929E-18 M=1.0
C9355 GD 288  2.52313605E-15 M=1.0
C9356 GD 5  6.76993095E-15 M=1.0
C9357 VD 323  164.0043E-18 M=1.0
C9358 VD 236  123.2487E-18 M=1.0
C9359 VD 36  313.9407E-18 M=1.0
C9360 VD 5  186.417E-18 M=1.0
C9361 329 334  75.2751E-18 M=1.0
C9362 329 332  42.8976E-18 M=1.0
C9363 329 330  79.011E-18 M=1.0
C9364 GD 558  248.281199999999E-18 M=1.0
C9365 GD 557  209.7819E-18 M=1.0
C9366 GD 513  64.4273999999999E-18 M=1.0
C9367 GD 508  69.9272999999999E-18 M=1.0
C9368 GD 486  69.9273000000001E-18 M=1.0
C9369 GD 469  69.9273000000001E-18 M=1.0
C9370 GD 438  204.282E-18 M=1.0
C9371 GD 437  254.5668E-18 M=1.0
C9372 GD 283  282.851999999999E-18 M=1.0
C9373 VD 558  40.0706999999996E-18 M=1.0
C9374 VD 513  33.7850999999998E-18 M=1.0
C9375 VD 438  74.6414999999991E-18 M=1.0
C9376 VD 437  81.7128E-18 M=1.0
C9377 513 558  75.2328E-18 M=1.0
C9378 438 498  454.8447E-18 M=1.0
C9379 GD 558  239.9328E-18 M=1.0
C9380 GD 557  239.9328E-18 M=1.0
C9381 GD 550  164.349E-18 M=1.0
C9382 GD 517  44.0136000000006E-18 M=1.0
C9383 GD 513  219.542399999999E-18 M=1.0
C9384 GD 508  189.5436E-18 M=1.0
C9385 GD 498  191.6757E-18 M=1.0
C9386 GD 486  189.5436E-18 M=1.0
C9387 GD 469  189.5436E-18 M=1.0
C9388 GD 464  44.0136000000006E-18 M=1.0
C9389 VD 513  67.8456000000002E-18 M=1.0
C9390 VD 486  30.4271999999999E-18 M=1.0
C9391 VD 469  30.4271999999999E-18 M=1.0
C9392 VD 438  106.011E-18 M=1.0
C9393 VD 437  102.8232E-18 M=1.0
C9394 558 871  34.9776E-18 M=1.0
C9395 517 557  34.9776E-18 M=1.0
C9396 508 557  100.0224E-18 M=1.0
C9397 498 871  68.7384E-18 M=1.0
C9398 498 558  127.7451E-18 M=1.0
C9399 490 557  139.9104E-18 M=1.0
C9400 490 550  65.0448E-18 M=1.0
C9401 490 508  135E-18 M=1.0
C9402 486 871  34.9776E-18 M=1.0
C9403 486 558  100.0224E-18 M=1.0
C9404 469 871  34.9776E-18 M=1.0
C9405 469 558  69.9552E-18 M=1.0
C9406 469 486  100.0224E-18 M=1.0
C9407 464 557  34.9776E-18 M=1.0
C9408 464 490  69.2000999999999E-18 M=1.0
C9409 438 871  34.9776E-18 M=1.0
C9410 438 558  104.9328E-18 M=1.0
C9411 438 498  65.0448000000001E-18 M=1.0
C9412 438 486  100.0224E-18 M=1.0
C9413 438 469  100.0224E-18 M=1.0
C9414 437 557  139.9104E-18 M=1.0
C9415 437 517  34.9776E-18 M=1.0
C9416 437 508  100.0224E-18 M=1.0
C9417 437 490  169.9776E-18 M=1.0
C9418 437 464  69.9552E-18 M=1.0
C9419 283 557  174.888E-18 M=1.0
C9420 283 508  100.0224E-18 M=1.0
C9421 283 490  204.9552E-18 M=1.0
C9422 283 464  34.9776E-18 M=1.0
C9423 283 437  174.888E-18 M=1.0
C9424 GD 558  456.8508E-18 M=1.0
C9425 GD 557  397.0251E-18 M=1.0
C9426 GD 517  65.9682000000001E-18 M=1.0
C9427 GD 508  326.322E-18 M=1.0
C9428 GD 490  799.4889E-18 M=1.0
C9429 GD 486  146.8449E-18 M=1.0
C9430 GD 469  230.8167E-18 M=1.0
C9431 GD 464  66.4299000000001E-18 M=1.0
C9432 GD 283  623.8467E-18 M=1.0
C9433 VD 871  65.9681999999999E-18 M=1.0
C9434 VD 438  527.5539E-18 M=1.0
C9435 VD 437  689.1111E-18 M=1.0
C9436 558 871  54.015525E-18 M=1.0
C9437 557 558  85.5747E-18 M=1.0
C9438 550 558  122.156775E-18 M=1.0
C9439 513 540  146.418975E-18 M=1.0
C9440 508 558  122.0454E-18 M=1.0
C9441 498 558  96.7077E-18 M=1.0
C9442 490 558  144.4914E-18 M=1.0
C9443 486 558  101.11905E-18 M=1.0
C9444 469 558  25.6374E-18 M=1.0
C9445 438 558  52.3044E-18 M=1.0
C9446 438 464  70.614E-18 M=1.0
C9447 437 558  208.9368E-18 M=1.0
C9448 437 557  52.3044E-18 M=1.0
C9449 283 558  162.30465E-18 M=1.0
C9450 283 557  52.3044E-18 M=1.0
C9451 283 437  51.2748E-18 M=1.0
C9452 GD 594  1.051972425E-15 M=1.0
C9453 GD 558  730.07595E-18 M=1.0
C9454 GD 540  795.704175E-18 M=1.0
C9455 GD 498  1.1747916E-15 M=1.0
C9456 VD 540  626.2398E-18 M=1.0
C9457 VD 438  181.03095E-18 M=1.0
C9458 GD 556  209.781900000001E-18 M=1.0
C9459 GD 507  69.9273000000003E-18 M=1.0
C9460 GD 506  69.9273E-18 M=1.0
C9461 GD 439  254.566800000001E-18 M=1.0
C9462 GD 110  209.7819E-18 M=1.0
C9463 GD 35  282.852E-18 M=1.0
C9464 GD 4  254.566800000001E-18 M=1.0
C9465 VD 556  40.0706999999996E-18 M=1.0
C9466 VD 487  26.7138000000002E-18 M=1.0
C9467 VD 439  81.7128E-18 M=1.0
C9468 VD 288  53.4275999999995E-18 M=1.0
C9469 VD 110  40.0707000000003E-18 M=1.0
C9470 VD 35  53.4276000000004E-18 M=1.0
C9471 VD 4  81.7127999999996E-18 M=1.0
C9472 GD 556  239.9328E-18 M=1.0
C9473 GD 549  164.349E-18 M=1.0
C9474 GD 548  164.349E-18 M=1.0
C9475 GD 515  44.0136000000003E-18 M=1.0
C9476 GD 507  189.5436E-18 M=1.0
C9477 GD 506  189.5436E-18 M=1.0
C9478 GD 488  214.7382E-18 M=1.0
C9479 GD 462  44.0136000000003E-18 M=1.0
C9480 GD 288  253.53E-18 M=1.0
C9481 GD 110  136.2294E-18 M=1.0
C9482 GD 35  133.0416E-18 M=1.0
C9483 VD 549  106.011000000001E-18 M=1.0
C9484 VD 507  30.4272000000001E-18 M=1.0
C9485 VD 506  30.4271999999998E-18 M=1.0
C9486 VD 488  30.4272000000001E-18 M=1.0
C9487 VD 487  30.4271999999998E-18 M=1.0
C9488 VD 439  102.8232E-18 M=1.0
C9489 556 875  34.9776E-18 M=1.0
C9490 556 868  34.9776E-18 M=1.0
C9491 507 556  100.0224E-18 M=1.0
C9492 488 868  69.2000999999999E-18 M=1.0
C9493 488 556  139.9104E-18 M=1.0
C9494 488 549  65.0448E-18 M=1.0
C9495 488 507  135E-18 M=1.0
C9496 487 867  69.2000999999999E-18 M=1.0
C9497 487 548  65.0447999999999E-18 M=1.0
C9498 487 506  135E-18 M=1.0
C9499 462 487  69.2001E-18 M=1.0
C9500 439 875  34.9776E-18 M=1.0
C9501 439 868  69.9552E-18 M=1.0
C9502 439 556  139.9104E-18 M=1.0
C9503 439 507  100.0224E-18 M=1.0
C9504 439 488  169.9776E-18 M=1.0
C9505 288 868  34.9776E-18 M=1.0
C9506 288 556  174.888E-18 M=1.0
C9507 288 507  100.0224E-18 M=1.0
C9508 288 488  204.9552E-18 M=1.0
C9509 288 439  174.888E-18 M=1.0
C9510 110 874  34.9776E-18 M=1.0
C9511 110 867  34.9776E-18 M=1.0
C9512 110 515  34.9776E-18 M=1.0
C9513 110 506  100.0224E-18 M=1.0
C9514 110 487  139.9104E-18 M=1.0
C9515 110 462  34.9776E-18 M=1.0
C9516 35 867  34.9776E-18 M=1.0
C9517 35 506  100.0224E-18 M=1.0
C9518 35 487  204.9552E-18 M=1.0
C9519 35 462  34.9776E-18 M=1.0
C9520 35 110  174.888E-18 M=1.0
C9521 4 874  34.9776E-18 M=1.0
C9522 4 867  69.9552E-18 M=1.0
C9523 4 515  34.9776E-18 M=1.0
C9524 4 506  100.0224E-18 M=1.0
C9525 4 487  169.9776E-18 M=1.0
C9526 4 462  69.9552E-18 M=1.0
C9527 4 110  139.9104E-18 M=1.0
C9528 4 35  174.888E-18 M=1.0
C9529 GD 556  397.0251E-18 M=1.0
C9530 GD 515  65.9681999999999E-18 M=1.0
C9531 GD 507  326.322E-18 M=1.0
C9532 GD 506  326.322E-18 M=1.0
C9533 GD 488  799.4889E-18 M=1.0
C9534 GD 487  799.4889E-18 M=1.0
C9535 GD 462  66.4299E-18 M=1.0
C9536 GD 288  623.8467E-18 M=1.0
C9537 GD 35  13.8179871E-15 M=1.0
C9538 VD 875  65.9682E-18 M=1.0
C9539 VD 874  65.9682E-18 M=1.0
C9540 VD 868  66.4299E-18 M=1.0
C9541 VD 867  66.4299000000001E-18 M=1.0
C9542 VD 439  689.1111E-18 M=1.0
C9543 VD 4  689.1111E-18 M=1.0
C9544 556 868  69.6825E-18 M=1.0
C9545 556 557  131.5908E-18 M=1.0
C9546 507 557  122.0454E-18 M=1.0
C9547 506 556  122.0454E-18 M=1.0
C9548 488 557  144.783E-18 M=1.0
C9549 488 549  118.854E-18 M=1.0
C9550 487 556  144.4914E-18 M=1.0
C9551 462 556  69.156E-18 M=1.0
C9552 439 868  52.3044000000001E-18 M=1.0
C9553 439 557  244.9728E-18 M=1.0
C9554 439 556  52.3044E-18 M=1.0
C9555 439 462  52.3044E-18 M=1.0
C9556 288 868  52.3044000000001E-18 M=1.0
C9557 288 557  129.2166E-18 M=1.0
C9558 288 556  52.3044E-18 M=1.0
C9559 288 462  52.3044E-18 M=1.0
C9560 110 867  52.6203E-18 M=1.0
C9561 110 556  134.5482E-18 M=1.0
C9562 110 141  52.3044E-18 M=1.0
C9563 35 867  52.3044E-18 M=1.0
C9564 35 556  129.2166E-18 M=1.0
C9565 35 288  124.1676E-18 M=1.0
C9566 35 141  52.3044E-18 M=1.0
C9567 35 110  104.6088E-18 M=1.0
C9568 35 109  52.3044E-18 M=1.0
C9569 4 867  52.6203E-18 M=1.0
C9570 4 556  208.9368E-18 M=1.0
C9571 4 439  46.3806E-18 M=1.0
C9572 4 288  51.2748E-18 M=1.0
C9573 4 141  56.8817999999999E-18 M=1.0
C9574 4 110  109.1862E-18 M=1.0
C9575 4 109  56.8817999999999E-18 M=1.0
C9576 4 35  109.1862E-18 M=1.0
C9577 4 34  56.8818000000001E-18 M=1.0
C9578 4 33  56.8818000000001E-18 M=1.0
C9579 GD 557  720.77535E-18 M=1.0
C9580 GD 556  779.121E-18 M=1.0
C9581 GD 439  610.1334E-18 M=1.0
C9582 GD 437  619.9893E-18 M=1.0
C9583 GD 4  6.1862445E-15 M=1.0
C9584 VD 556  493.43985E-18 M=1.0
C9585 VD 439  123.8805E-18 M=1.0
C9586 VD 288  403.58295E-18 M=1.0
C9587 VD 110  267.514875E-18 M=1.0
C9588 VD 35  302.508E-18 M=1.0
C9589 VD 4  203.4279E-18 M=1.0
C9590 GD 774  76.2129E-18 M=1.0
C9591 GD 773  70.7129999999996E-18 M=1.0
C9592 GD 720  23.571E-18 M=1.0
C9593 GD 701  254.566799999999E-18 M=1.0
C9594 GD 698  69.9273000000009E-18 M=1.0
C9595 GD 697  139.8546E-18 M=1.0
C9596 GD 659  84.0698999999997E-18 M=1.0
C9597 VD 720  36.9279E-18 M=1.0
C9598 VD 697  26.7137999999998E-18 M=1.0
C9599 VD 634  81.7127999999999E-18 M=1.0
C9600 VD 593  147.7116E-18 M=1.0
C9601 VD 588  53.4276E-18 M=1.0
C9602 VD 537  53.4276E-18 M=1.0
C9603 VD 529  40.0706999999998E-18 M=1.0
C9604 773 774  171.7443E-18 M=1.0
C9605 722 773  75.2328E-18 M=1.0
C9606 659 773  75.2328E-18 M=1.0
C9607 GD 775  202.6413E-18 M=1.0
C9608 GD 774  226.8738E-18 M=1.0
C9609 GD 773  250.783199999999E-18 M=1.0
C9610 GD 722  364.212E-18 M=1.0
C9611 GD 720  82.5975E-18 M=1.0
C9612 GD 701  164.349E-18 M=1.0
C9613 VD 775  30.4271999999999E-18 M=1.0
C9614 VD 774  30.4272000000001E-18 M=1.0
C9615 VD 720  50.8401E-18 M=1.0
C9616 VD 659  50.8401E-18 M=1.0
C9617 722 774  74.9664E-18 M=1.0
C9618 722 773  117.0432E-18 M=1.0
C9619 697 700  65.0448E-18 M=1.0
C9620 629 701  69.9552E-18 M=1.0
C9621 GD 721  11.9710746E-15 M=1.0
C9622 GD 720  585.98955E-18 M=1.0
C9623 GD 661  31.6845E-18 M=1.0
C9624 GD 593  10.08441495E-15 M=1.0
C9625 VD 720  279.32265E-18 M=1.0
C9626 722 775  69.741E-18 M=1.0
C9627 701 889  76.7709E-18 M=1.0
C9628 700 721  725.2551E-18 M=1.0
C9629 659 721  409.4874E-18 M=1.0
C9630 633 721  61.5321E-18 M=1.0
C9631 593 633  61.5321E-18 M=1.0
C9632 GD 701  458.982225E-18 M=1.0
C9633 GD 633  2.00069955E-15 M=1.0
C9634 VD 701  172.6506E-18 M=1.0
C9635 VD 634  1.056453075E-15 M=1.0
C9636 523 701  25.2936E-18 M=1.0
C9637 523 629  238.7961E-18 M=1.0
C9638 GD 634  254.566799999999E-18 M=1.0
C9639 GD 631  69.9272999999992E-18 M=1.0
C9640 GD 630  139.8546E-18 M=1.0
C9641 GD 537  282.852000000001E-18 M=1.0
C9642 GD 529  209.7819E-18 M=1.0
C9643 GD 523  282.851999999996E-18 M=1.0
C9644 GD 489  209.7819E-18 M=1.0
C9645 VD 701  81.7127999999998E-18 M=1.0
C9646 VD 630  26.7138000000002E-18 M=1.0
C9647 VD 523  53.4276E-18 M=1.0
C9648 VD 489  40.0706999999998E-18 M=1.0
C9649 GD 693  44.0136E-18 M=1.0
C9650 GD 691  214.7382E-18 M=1.0
C9651 GD 690  44.0136E-18 M=1.0
C9652 GD 633  174.8907E-18 M=1.0
C9653 GD 632  44.0136E-18 M=1.0
C9654 GD 631  189.5436E-18 M=1.0
C9655 GD 630  214.7382E-18 M=1.0
C9656 GD 629  44.0136E-18 M=1.0
C9657 GD 537  256.2237E-18 M=1.0
C9658 GD 529  259.4115E-18 M=1.0
C9659 GD 523  256.2237E-18 M=1.0
C9660 GD 489  259.4115E-18 M=1.0
C9661 VD 701  102.8232E-18 M=1.0
C9662 VD 692  30.4271999999999E-18 M=1.0
C9663 VD 691  30.4271999999999E-18 M=1.0
C9664 VD 634  102.8232E-18 M=1.0
C9665 VD 631  30.4271999999999E-18 M=1.0
C9666 VD 630  30.4272000000001E-18 M=1.0
C9667 701 890  34.9776E-18 M=1.0
C9668 701 889  69.9552E-18 M=1.0
C9669 691 907  69.2001E-18 M=1.0
C9670 691 692  135E-18 M=1.0
C9671 690 691  69.2001E-18 M=1.0
C9672 634 908  34.9776E-18 M=1.0
C9673 634 907  69.9552E-18 M=1.0
C9674 634 693  34.9776E-18 M=1.0
C9675 634 692  100.0224E-18 M=1.0
C9676 634 691  169.9776E-18 M=1.0
C9677 634 690  69.9552E-18 M=1.0
C9678 632 701  34.9776E-18 M=1.0
C9679 631 701  100.0224E-18 M=1.0
C9680 630 889  69.2001E-18 M=1.0
C9681 630 701  169.9776E-18 M=1.0
C9682 630 633  65.0448E-18 M=1.0
C9683 630 631  135E-18 M=1.0
C9684 629 630  69.2001E-18 M=1.0
C9685 537 907  34.9776E-18 M=1.0
C9686 537 692  100.0224E-18 M=1.0
C9687 537 691  204.9552E-18 M=1.0
C9688 537 690  34.9776E-18 M=1.0
C9689 537 634  174.888E-18 M=1.0
C9690 529 908  34.9776E-18 M=1.0
C9691 529 907  34.9776E-18 M=1.0
C9692 529 693  34.9776E-18 M=1.0
C9693 529 692  100.0224E-18 M=1.0
C9694 529 691  139.9104E-18 M=1.0
C9695 529 690  34.9776E-18 M=1.0
C9696 529 634  139.9104E-18 M=1.0
C9697 529 537  174.888E-18 M=1.0
C9698 523 889  34.9776E-18 M=1.0
C9699 523 701  174.888E-18 M=1.0
C9700 523 631  100.0224E-18 M=1.0
C9701 523 630  204.9552E-18 M=1.0
C9702 523 629  34.9776E-18 M=1.0
C9703 489 890  34.9776E-18 M=1.0
C9704 489 889  34.9776E-18 M=1.0
C9705 489 701  139.9104E-18 M=1.0
C9706 489 632  34.9776E-18 M=1.0
C9707 489 631  100.0224E-18 M=1.0
C9708 489 630  139.9104E-18 M=1.0
C9709 489 629  34.9776E-18 M=1.0
C9710 489 523  174.888E-18 M=1.0
C9711 GD 693  65.9682E-18 M=1.0
C9712 GD 692  326.322E-18 M=1.0
C9713 GD 691  799.4889E-18 M=1.0
C9714 GD 690  66.4299E-18 M=1.0
C9715 GD 632  65.9682E-18 M=1.0
C9716 GD 631  326.322E-18 M=1.0
C9717 GD 630  799.4889E-18 M=1.0
C9718 GD 629  66.4299E-18 M=1.0
C9719 GD 537  623.8467E-18 M=1.0
C9720 GD 529  4.4809191E-15 M=1.0
C9721 GD 523  623.8467E-18 M=1.0
C9722 GD 489  431.35605E-18 M=1.0
C9723 VD 908  65.9682E-18 M=1.0
C9724 VD 907  66.4299E-18 M=1.0
C9725 VD 890  65.9682E-18 M=1.0
C9726 VD 889  66.4299E-18 M=1.0
C9727 VD 701  689.1111E-18 M=1.0
C9728 VD 634  689.1111E-18 M=1.0
C9729 634 907  70.1847E-18 M=1.0
C9730 634 890  52.3044E-18 M=1.0
C9731 634 701  296.7165E-18 M=1.0
C9732 634 691  52.3044E-18 M=1.0
C9733 633 908  56.8818E-18 M=1.0
C9734 633 693  56.8818E-18 M=1.0
C9735 633 692  56.8818E-18 M=1.0
C9736 633 691  56.8818E-18 M=1.0
C9737 633 634  107.5266E-18 M=1.0
C9738 631 634  564.39E-18 M=1.0
C9739 630 634  56.3148E-18 M=1.0
C9740 538 593  118.4868E-18 M=1.0
C9741 537 701  56.8818E-18 M=1.0
C9742 537 690  56.8818E-18 M=1.0
C9743 537 634  249.07815E-18 M=1.0
C9744 537 633  56.8818E-18 M=1.0
C9745 537 630  56.8818E-18 M=1.0
C9746 529 701  320.19345E-18 M=1.0
C9747 529 691  239.26995E-18 M=1.0
C9748 529 690  52.3044E-18 M=1.0
C9749 529 634  320.19345E-18 M=1.0
C9750 529 633  265.0752E-18 M=1.0
C9751 529 630  52.3044E-18 M=1.0
C9752 529 593  61.5321E-18 M=1.0
C9753 523 634  67.5702E-18 M=1.0
C9754 523 537  74.0250000000001E-18 M=1.0
C9755 523 529  52.3044E-18 M=1.0
C9756 489 634  77.796E-18 M=1.0
C9757 489 630  56.8818E-18 M=1.0
C9758 489 629  56.8818E-18 M=1.0
C9759 489 529  52.3044E-18 M=1.0
C9760 GD 634  853.869825E-18 M=1.0
C9761 GD 537  822.499875E-18 M=1.0
C9762 GD 529  1.940967E-15 M=1.0
C9763 VD 633  576.4284E-18 M=1.0
C9764 VD 537  220.83165E-18 M=1.0
C9765 VD 529  667.639575E-18 M=1.0
C9766 489 537  191.26395E-18 M=1.0
C9767 GD 523  1.2557592E-15 M=1.0
C9768 GD 661  254.566800000004E-18 M=1.0
C9769 GD 660  64.4273999999997E-18 M=1.0
C9770 GD 658  69.9273000000009E-18 M=1.0
C9771 GD 657  69.9272999999993E-18 M=1.0
C9772 GD 618  204.282000000004E-18 M=1.0
C9773 GD 588  282.851999999999E-18 M=1.0
C9774 GD 571  248.281200000003E-18 M=1.0
C9775 GD 472  209.781900000001E-18 M=1.0
C9776 VD 661  81.7128000000002E-18 M=1.0
C9777 VD 660  33.7850999999998E-18 M=1.0
C9778 VD 618  74.6415E-18 M=1.0
C9779 VD 571  40.0706999999999E-18 M=1.0
C9780 VD 472  40.0706999999998E-18 M=1.0
C9781 618 659  454.8447E-18 M=1.0
C9782 571 660  75.2328E-18 M=1.0
C9783 GD 699  44.0135999999999E-18 M=1.0
C9784 GD 698  189.5436E-18 M=1.0
C9785 GD 697  214.7382E-18 M=1.0
C9786 GD 696  44.0136E-18 M=1.0
C9787 GD 661  164.349E-18 M=1.0
C9788 GD 660  219.5424E-18 M=1.0
C9789 GD 658  189.5436E-18 M=1.0
C9790 GD 657  189.5436E-18 M=1.0
C9791 GD 588  256.2237E-18 M=1.0
C9792 GD 571  259.4115E-18 M=1.0
C9793 VD 698  30.4271999999999E-18 M=1.0
C9794 VD 697  30.4272000000001E-18 M=1.0
C9795 VD 661  102.8232E-18 M=1.0
C9796 VD 660  67.8455999999999E-18 M=1.0
C9797 VD 658  30.4271999999999E-18 M=1.0
C9798 VD 657  30.4272000000001E-18 M=1.0
C9799 VD 618  106.011E-18 M=1.0
C9800 697 909  69.2001E-18 M=1.0
C9801 697 698  135E-18 M=1.0
C9802 696 697  69.2001E-18 M=1.0
C9803 661 910  34.9776E-18 M=1.0
C9804 661 909  69.9552E-18 M=1.0
C9805 661 699  34.9776E-18 M=1.0
C9806 661 698  100.0224E-18 M=1.0
C9807 661 697  169.9776E-18 M=1.0
C9808 661 696  69.9552E-18 M=1.0
C9809 659 887  68.7384E-18 M=1.0
C9810 658 887  34.9776E-18 M=1.0
C9811 657 887  34.9776E-18 M=1.0
C9812 657 658  100.0224E-18 M=1.0
C9813 618 887  34.9776E-18 M=1.0
C9814 618 659  65.0448E-18 M=1.0
C9815 618 658  100.0224E-18 M=1.0
C9816 618 657  100.0224E-18 M=1.0
C9817 588 909  34.9776E-18 M=1.0
C9818 588 698  100.0224E-18 M=1.0
C9819 588 697  204.9552E-18 M=1.0
C9820 588 696  34.9776E-18 M=1.0
C9821 588 661  174.888E-18 M=1.0
C9822 571 887  34.9776E-18 M=1.0
C9823 571 659  127.7451E-18 M=1.0
C9824 571 658  100.0224E-18 M=1.0
C9825 571 657  69.9552E-18 M=1.0
C9826 571 618  104.9328E-18 M=1.0
C9827 472 910  34.9776E-18 M=1.0
C9828 472 909  34.9776E-18 M=1.0
C9829 472 699  34.9776E-18 M=1.0
C9830 472 698  100.0224E-18 M=1.0
C9831 472 697  139.9104E-18 M=1.0
C9832 472 696  34.9776E-18 M=1.0
C9833 472 661  139.9104E-18 M=1.0
C9834 472 588  174.888E-18 M=1.0
C9835 GD 699  65.9682E-18 M=1.0
C9836 GD 698  326.322E-18 M=1.0
C9837 GD 697  799.4889E-18 M=1.0
C9838 GD 696  66.4299E-18 M=1.0
C9839 GD 658  146.8449E-18 M=1.0
C9840 GD 657  230.8167E-18 M=1.0
C9841 GD 588  623.8467E-18 M=1.0
C9842 GD 571  456.8508E-18 M=1.0
C9843 VD 910  65.9682E-18 M=1.0
C9844 VD 909  66.4299E-18 M=1.0
C9845 VD 887  65.9682E-18 M=1.0
C9846 VD 661  689.1111E-18 M=1.0
C9847 VD 618  527.5539E-18 M=1.0
C9848 661 909  52.6203E-18 M=1.0
C9849 661 697  52.3044E-18 M=1.0
C9850 660 661  112.2264E-18 M=1.0
C9851 659 698  78.4476000000001E-18 M=1.0
C9852 659 697  73.7334E-18 M=1.0
C9853 659 661  195.023025E-18 M=1.0
C9854 658 661  203.14125E-18 M=1.0
C9855 618 661  138.9186E-18 M=1.0
C9856 618 659  163.72215E-18 M=1.0
C9857 588 909  208.750725E-18 M=1.0
C9858 588 887  70.6869E-18 M=1.0
C9859 588 697  87.923025E-18 M=1.0
C9860 588 661  395.96355E-18 M=1.0
C9861 588 659  129.9996E-18 M=1.0
C9862 588 658  80.5347E-18 M=1.0
C9863 588 657  279.4041E-18 M=1.0
C9864 588 618  52.3044E-18 M=1.0
C9865 571 661  235.0107E-18 M=1.0
C9866 571 659  28.2303E-18 M=1.0
C9867 571 618  56.8818E-18 M=1.0
C9868 571 606  61.5321000000001E-18 M=1.0
C9869 571 588  124.614E-18 M=1.0
C9870 472 697  237.105E-18 M=1.0
C9871 472 696  52.3044E-18 M=1.0
C9872 472 661  311.14395E-18 M=1.0
C9873 472 659  56.8818E-18 M=1.0
C9874 472 658  333.783675E-18 M=1.0
C9875 472 657  52.3044E-18 M=1.0
C9876 472 618  52.3044E-18 M=1.0
C9877 472 571  52.3044E-18 M=1.0
C9878 GD 661  1.187879175E-15 M=1.0
C9879 GD 659  2.420010675E-15 M=1.0
C9880 GD 588  1.664765775E-15 M=1.0
C9881 VD 661  1.232814375E-15 M=1.0
C9882 VD 659  341.723925E-18 M=1.0
C9883 VD 618  121.986225E-18 M=1.0
C9884 VD 588  502.62885E-18 M=1.0
C9885 VD 571  265.47165E-18 M=1.0
C9886 VD 489  47.3742E-18 M=1.0
C9887 VD 472  355.44465E-18 M=1.0
C9888 523 618  25.0668E-18 M=1.0
C9889 523 588  386.85285E-18 M=1.0
C9890 523 571  25.0668E-18 M=1.0
C9891 472 523  68.89365E-18 M=1.0
C9892 VD 537  40.54545E-18 M=1.0
C9893 GD 779  70.7130000000002E-18 M=1.0
C9894 GD 778  91.1412000000002E-18 M=1.0
C9895 GD 777  76.2128999999999E-18 M=1.0
C9896 GD 776  70.713E-18 M=1.0
C9897 GD 775  91.1411999999978E-18 M=1.0
C9898 GD 722  593.9892E-18 M=1.0
C9899 GD 721  94.2840000000006E-18 M=1.0
C9900 GD 700  84.0699000000005E-18 M=1.0
C9901 GD 633  84.0698999999992E-18 M=1.0
C9902 VD 722  106.8552E-18 M=1.0
C9903 VD 721  147.7116E-18 M=1.0
C9904 776 777  171.7443E-18 M=1.0
C9905 722 779  75.2328E-18 M=1.0
C9906 722 776  75.2328E-18 M=1.0
C9907 700 776  75.2328E-18 M=1.0
C9908 633 779  75.2328E-18 M=1.0
C9909 GD 779  250.7832E-18 M=1.0
C9910 GD 778  202.6413E-18 M=1.0
C9911 GD 777  226.8738E-18 M=1.0
C9912 GD 776  250.7832E-18 M=1.0
C9913 GD 700  174.8907E-18 M=1.0
C9914 S_6 GD  183.8277E-18 M=1.0
C9915 S_5 GD  183.8277E-18 M=1.0
C9916 VD 780  30.4272E-18 M=1.0
C9917 VD 779  45.4923E-18 M=1.0
C9918 VD 778  30.4272000000001E-18 M=1.0
C9919 VD 777  30.4271999999999E-18 M=1.0
C9920 VD 776  45.4922999999999E-18 M=1.0
C9921 VD 722  30.4272E-18 M=1.0
C9922 VD 700  50.8401000000001E-18 M=1.0
C9923 VD 633  50.8401E-18 M=1.0
C9924 VD S_6  30.4272000000001E-18 M=1.0
C9925 VD S_5  30.4271999999999E-18 M=1.0
C9926 722 777  74.9664E-18 M=1.0
C9927 722 776  117.0432E-18 M=1.0
C9928 700 722  80.0208E-18 M=1.0
C9929 633 722  42.0768E-18 M=1.0
C9930 S_6 GD  34.33095E-18 M=1.0
C9931 722 779  44.1036E-18 M=1.0
C9932 722 778  69.741E-18 M=1.0
C9933 722 776  44.1036E-18 M=1.0
C9934 633 722  25.6374E-18 M=1.0
C9935 GD 700  1.693103175E-15 M=1.0
C9936 S_6 722  332.2782E-18 M=1.0
C9937 S_5 722  44.1036E-18 M=1.0
C9938 VD 722  218.06235E-18 M=1.0
C9939 VD 700  324.291825E-18 M=1.0
C9940 GD 772  91.1412000000008E-18 M=1.0
C9941 GD 771  76.2129000000002E-18 M=1.0
C9942 GD 770  70.7130000000004E-18 M=1.0
C9943 GD 744  70.7129999999992E-18 M=1.0
C9944 GD 743  76.2129000000014E-18 M=1.0
C9945 GD 655  84.0698999999988E-18 M=1.0
C9946 VD 719  133.569E-18 M=1.0
C9947 770 771  171.7443E-18 M=1.0
C9948 743 744  171.7443E-18 M=1.0
C9949 719 744  75.2328E-18 M=1.0
C9950 655 744  75.2327999999998E-18 M=1.0
C9951 GD 772  202.6413E-18 M=1.0
C9952 GD 771  226.8738E-18 M=1.0
C9953 GD 770  250.7832E-18 M=1.0
C9954 GD 744  250.783200000001E-18 M=1.0
C9955 GD 743  226.8738E-18 M=1.0
C9956 GD 721  334.02825E-18 M=1.0
C9957 GD 659  191.6757E-18 M=1.0
C9958 GD 655  191.6757E-18 M=1.0
C9959 S_4 GD  183.8277E-18 M=1.0
C9960 VD 773  45.4923000000001E-18 M=1.0
C9961 VD 772  60.6212999999999E-18 M=1.0
C9962 VD 771  30.4272000000001E-18 M=1.0
C9963 VD 745  30.4271999999999E-18 M=1.0
C9964 VD 744  45.4923000000001E-18 M=1.0
C9965 VD 743  30.4272000000001E-18 M=1.0
C9966 VD 721  80.8164E-18 M=1.0
C9967 VD 655  50.8401000000002E-18 M=1.0
C9968 VD S_4  30.4272000000001E-18 M=1.0
C9969 745 771  74.9664E-18 M=1.0
C9970 745 770  117.0432E-18 M=1.0
C9971 719 744  117.0432E-18 M=1.0
C9972 719 743  74.9664000000001E-18 M=1.0
C9973 659 722  42.0768E-18 M=1.0
C9974 655 719  83.7648E-18 M=1.0
C9975 S_4 GD  31.6845E-18 M=1.0
C9976 VD 721  487.93635E-18 M=1.0
C9977 745 772  69.741E-18 M=1.0
C9978 722 773  44.1036E-18 M=1.0
C9979 719 743  25.3224E-18 M=1.0
C9980 659 722  25.6374E-18 M=1.0
C9981 655 743  69.741E-18 M=1.0
C9982 GD 722  1.886257125E-15 M=1.0
C9983 S_4 745  44.1036E-18 M=1.0
C9984 VD 655  614.0322E-18 M=1.0
C9985 GD 763  91.1411999999972E-18 M=1.0
C9986 GD 745  742.486500000007E-18 M=1.0
C9987 GD 734  91.1411999999987E-18 M=1.0
C9988 GD 715  64.4273999999999E-18 M=1.0
C9989 GD 714  64.4274000000002E-18 M=1.0
C9990 GD 707  64.4273999999999E-18 M=1.0
C9991 GD 705  84.0698999999988E-18 M=1.0
C9992 GD 648  204.282E-18 M=1.0
C9993 GD 33  248.2812E-18 M=1.0
C9994 VD 718  40.0707000000003E-18 M=1.0
C9995 VD 717  40.0706999999996E-18 M=1.0
C9996 VD 716  36.9279000000003E-18 M=1.0
C9997 VD 715  33.7851000000002E-18 M=1.0
C9998 VD 714  33.7851E-18 M=1.0
C9999 VD 707  33.7851E-18 M=1.0
C10000 VD 649  74.6415000000006E-18 M=1.0
C10001 VD 648  74.6414999999999E-18 M=1.0
C10002 VD 622  33.7851E-18 M=1.0
C10003 VD 549  74.6415000000005E-18 M=1.0
C10004 VD 33  40.0707000000003E-18 M=1.0
C10005 VD 2  74.6415000000005E-18 M=1.0
C10006 715 717  75.2327999999999E-18 M=1.0
C10007 707 718  75.2327999999999E-18 M=1.0
C10008 648 706  454.8447E-18 M=1.0
C10009 622 653  75.2327999999999E-18 M=1.0
C10010 33 714  75.2327999999999E-18 M=1.0
C10011 2 705  454.8447E-18 M=1.0
C10012 GD 733  194.3694E-18 M=1.0
C10013 GD 732  250.7832E-18 M=1.0
C10014 GD 719  439.872750000001E-18 M=1.0
C10015 GD 718  239.9328E-18 M=1.0
C10016 GD 716  118.34505E-18 M=1.0
C10017 GD 715  219.5424E-18 M=1.0
C10018 GD 714  219.542399999999E-18 M=1.0
C10019 GD 707  219.5424E-18 M=1.0
C10020 GD 33  136.2294E-18 M=1.0
C10021 VD 764  45.4922999999997E-18 M=1.0
C10022 VD 732  45.4923000000001E-18 M=1.0
C10023 VD 719  30.4272000000001E-18 M=1.0
C10024 VD 718  30.4272000000001E-18 M=1.0
C10025 VD 717  30.4271999999998E-18 M=1.0
C10026 VD 716  46.1353500000002E-18 M=1.0
C10027 VD 715  67.8456000000001E-18 M=1.0
C10028 VD 714  67.8455999999999E-18 M=1.0
C10029 VD 713  30.4271999999999E-18 M=1.0
C10030 VD 707  67.8455999999999E-18 M=1.0
C10031 VD 704  50.8401000000001E-18 M=1.0
C10032 VD 656  30.4271999999999E-18 M=1.0
C10033 VD 654  30.4271999999999E-18 M=1.0
C10034 VD 649  106.011000000001E-18 M=1.0
C10035 VD 627  30.4271999999999E-18 M=1.0
C10036 VD 622  67.8455999999999E-18 M=1.0
C10037 S_1 GD  183.827700000001E-18 M=1.0
C10038 S_1 VD  30.4272000000001E-18 M=1.0
C10039 733 764  176.18625E-18 M=1.0
C10040 733 745  80.6040000000001E-18 M=1.0
C10041 718 895  34.9776E-18 M=1.0
C10042 717 898  34.9776E-18 M=1.0
C10043 706 898  68.7384E-18 M=1.0
C10044 706 717  127.7451E-18 M=1.0
C10045 705 897  68.7384000000001E-18 M=1.0
C10046 705 719  42.0768E-18 M=1.0
C10047 664 895  68.7384000000001E-18 M=1.0
C10048 656 895  34.9776E-18 M=1.0
C10049 654 895  34.9776E-18 M=1.0
C10050 649 895  34.9776E-18 M=1.0
C10051 649 718  104.9328E-18 M=1.0
C10052 649 664  65.0448000000001E-18 M=1.0
C10053 649 656  100.0224E-18 M=1.0
C10054 649 654  100.0224E-18 M=1.0
C10055 648 898  34.9776E-18 M=1.0
C10056 648 717  104.9328E-18 M=1.0
C10057 648 706  65.0448E-18 M=1.0
C10058 33 897  34.9776E-18 M=1.0
C10059 33 705  127.7451E-18 M=1.0
C10060 2 897  34.9776E-18 M=1.0
C10061 2 705  65.0448000000001E-18 M=1.0
C10062 2 33  104.9328E-18 M=1.0
C10063 GD 733  286.80615E-18 M=1.0
C10064 GD 717  456.8508E-18 M=1.0
C10065 GD 716  277.3737E-18 M=1.0
C10066 GD 33  17.2894815E-15 M=1.0
C10067 VD 895  65.9682E-18 M=1.0
C10068 VD 733  368.4519E-18 M=1.0
C10069 VD 649  527.5539E-18 M=1.0
C10070 VD 648  527.5539E-18 M=1.0
C10071 VD 606  508.6431E-18 M=1.0
C10072 S_1 GD  31.6845E-18 M=1.0
C10073 745 764  54.3294E-18 M=1.0
C10074 745 763  69.741E-18 M=1.0
C10075 733 745  25.6374E-18 M=1.0
C10076 719 733  73.85715E-18 M=1.0
C10077 719 732  59.5152E-18 M=1.0
C10078 718 895  202.053375E-18 M=1.0
C10079 717 718  76.9122E-18 M=1.0
C10080 715 718  162.298125E-18 M=1.0
C10081 714 717  69.741E-18 M=1.0
C10082 713 718  51.2748E-18 M=1.0
C10083 707 713  69.741E-18 M=1.0
C10084 706 718  88.2072E-18 M=1.0
C10085 706 717  103.5792E-18 M=1.0
C10086 706 715  69.741E-18 M=1.0
C10087 705 719  25.6374E-18 M=1.0
C10088 705 717  113.7402E-18 M=1.0
C10089 705 714  69.741E-18 M=1.0
C10090 664 719  59.6043E-18 M=1.0
C10091 664 716  104.226525E-18 M=1.0
C10092 664 713  113.9508E-18 M=1.0
C10093 664 707  174.613275E-18 M=1.0
C10094 656 718  44.9982E-18 M=1.0
C10095 655 719  551.379149999999E-18 M=1.0
C10096 655 716  188.7318E-18 M=1.0
C10097 655 704  78.606E-18 M=1.0
C10098 649 718  52.3044E-18 M=1.0
C10099 649 664  129.3534E-18 M=1.0
C10100 648 718  25.6374E-18 M=1.0
C10101 648 706  46.2348E-18 M=1.0
C10102 622 627  69.741E-18 M=1.0
C10103 549 627  43.6419E-18 M=1.0
C10104 33 717  58.9077E-18 M=1.0
C10105 33 705  413.919E-18 M=1.0
C10106 2 717  33.2703E-18 M=1.0
C10107 GD 718  688.442175E-18 M=1.0
C10108 GD 717  735.231375E-18 M=1.0
C10109 GD 706  1.840784175E-15 M=1.0
C10110 GD 705  1.74402045E-15 M=1.0
C10111 GD 664  2.065374225E-15 M=1.0
C10112 VD 718  297.95085E-18 M=1.0
C10113 VD 706  984.130425E-18 M=1.0
C10114 VD 664  875.076075E-18 M=1.0
C10115 VD 649  457.5573E-18 M=1.0
C10116 S_1 745  44.1036E-18 M=1.0
C10117 GD 718  248.281199999999E-18 M=1.0
C10118 GD 713  248.2812E-18 M=1.0
C10119 GD 683  64.4273999999999E-18 M=1.0
C10120 GD 656  69.9272999999999E-18 M=1.0
C10121 GD 654  69.9272999999999E-18 M=1.0
C10122 GD 653  248.281199999999E-18 M=1.0
C10123 GD 651  69.9273000000001E-18 M=1.0
C10124 GD 649  204.282E-18 M=1.0
C10125 GD 647  69.9273000000001E-18 M=1.0
C10126 GD 622  64.4273999999999E-18 M=1.0
C10127 GD 611  64.4273999999999E-18 M=1.0
C10128 GD 609  204.282E-18 M=1.0
C10129 VD 713  40.0706999999996E-18 M=1.0
C10130 VD 683  33.7850999999998E-18 M=1.0
C10131 VD 611  33.7850999999998E-18 M=1.0
C10132 VD 609  74.6414999999999E-18 M=1.0
C10133 683 713  75.2327999999999E-18 M=1.0
C10134 649 664  454.8447E-18 M=1.0
C10135 609 655  454.8447E-18 M=1.0
C10136 GD 713  239.9328E-18 M=1.0
C10137 GD 683  219.5424E-18 M=1.0
C10138 GD 656  189.5436E-18 M=1.0
C10139 GD 654  189.5436E-18 M=1.0
C10140 GD 651  189.5436E-18 M=1.0
C10141 GD 647  189.5436E-18 M=1.0
C10142 GD 622  219.5424E-18 M=1.0
C10143 VD 683  67.8456000000003E-18 M=1.0
C10144 VD 651  30.4272000000001E-18 M=1.0
C10145 VD 647  30.4272000000001E-18 M=1.0
C10146 VD 609  106.011E-18 M=1.0
C10147 713 888  34.9776E-18 M=1.0
C10148 664 718  127.7451E-18 M=1.0
C10149 656 718  100.0224E-18 M=1.0
C10150 655 888  68.7384E-18 M=1.0
C10151 655 713  127.7451E-18 M=1.0
C10152 654 718  69.9552E-18 M=1.0
C10153 654 656  100.0224E-18 M=1.0
C10154 651 888  34.9776E-18 M=1.0
C10155 651 713  100.0224E-18 M=1.0
C10156 647 888  34.9776E-18 M=1.0
C10157 647 713  69.9552E-18 M=1.0
C10158 647 651  100.0224E-18 M=1.0
C10159 609 888  34.9776E-18 M=1.0
C10160 609 713  104.9328E-18 M=1.0
C10161 609 655  65.0448000000001E-18 M=1.0
C10162 609 651  100.0224E-18 M=1.0
C10163 609 647  100.0224E-18 M=1.0
C10164 549 653  104.9328E-18 M=1.0
C10165 GD 718  456.8508E-18 M=1.0
C10166 GD 713  456.8508E-18 M=1.0
C10167 GD 656  146.8449E-18 M=1.0
C10168 GD 654  230.8167E-18 M=1.0
C10169 GD 653  456.8508E-18 M=1.0
C10170 GD 651  146.8449E-18 M=1.0
C10171 GD 647  230.8167E-18 M=1.0
C10172 VD 888  65.9681999999999E-18 M=1.0
C10173 VD 609  527.5539E-18 M=1.0
C10174 713 888  52.9098750000001E-18 M=1.0
C10175 704 713  76.9122E-18 M=1.0
C10176 683 704  185.6988E-18 M=1.0
C10177 664 718  95.9463E-18 M=1.0
C10178 656 713  25.6374E-18 M=1.0
C10179 655 713  449.278875000001E-18 M=1.0
C10180 655 683  69.741E-18 M=1.0
C10181 654 713  129.2454E-18 M=1.0
C10182 651 713  40.78665E-18 M=1.0
C10183 651 704  60.0345E-18 M=1.0
C10184 649 713  25.6374E-18 M=1.0
C10185 647 704  60.0345E-18 M=1.0
C10186 619 704  34.3971E-18 M=1.0
C10187 609 713  475.425E-18 M=1.0
C10188 609 704  76.9122E-18 M=1.0
C10189 GD 713  737.1162E-18 M=1.0
C10190 GD 704  1.794464325E-15 M=1.0
C10191 GD 655  1.54623375E-15 M=1.0
C10192 GD 609  715.4721E-18 M=1.0
C10193 VD 713  226.5876E-18 M=1.0
C10194 VD 609  154.79595E-18 M=1.0
C10195 GD 717  248.2812E-18 M=1.0
C10196 GD 703  69.9273000000003E-18 M=1.0
C10197 GD 702  69.9273000000001E-18 M=1.0
C10198 GD 663  69.9273000000003E-18 M=1.0
C10199 GD 662  69.9273000000001E-18 M=1.0
C10200 GD 617  69.9273000000003E-18 M=1.0
C10201 GD 616  69.9273E-18 M=1.0
C10202 GD 599  139.8546E-18 M=1.0
C10203 GD 598  139.8546E-18 M=1.0
C10204 GD 2  204.282E-18 M=1.0
C10205 VD 599  26.7137999999998E-18 M=1.0
C10206 VD 598  26.7138000000002E-18 M=1.0
C10207 VD 548  81.7128E-18 M=1.0
C10208 VD 109  40.0707000000003E-18 M=1.0
C10209 GD 717  239.932800000001E-18 M=1.0
C10210 GD 703  189.5436E-18 M=1.0
C10211 GD 702  189.5436E-18 M=1.0
C10212 GD 663  189.5436E-18 M=1.0
C10213 GD 662  189.5436E-18 M=1.0
C10214 GD 649  164.349E-18 M=1.0
C10215 GD 648  164.349E-18 M=1.0
C10216 GD 624  44.0136000000004E-18 M=1.0
C10217 GD 623  44.0136000000003E-18 M=1.0
C10218 GD 617  189.5436E-18 M=1.0
C10219 GD 616  189.5436E-18 M=1.0
C10220 GD 599  214.7382E-18 M=1.0
C10221 GD 598  214.7382E-18 M=1.0
C10222 GD 141  133.0416E-18 M=1.0
C10223 GD 34  133.0416E-18 M=1.0
C10224 VD 703  30.4272000000001E-18 M=1.0
C10225 VD 702  30.4271999999998E-18 M=1.0
C10226 VD 663  30.4272000000001E-18 M=1.0
C10227 VD 662  30.4271999999998E-18 M=1.0
C10228 VD 653  30.4272000000001E-18 M=1.0
C10229 VD 652  30.4271999999998E-18 M=1.0
C10230 VD 648  106.011E-18 M=1.0
C10231 VD 617  30.4272000000001E-18 M=1.0
C10232 VD 616  30.4271999999998E-18 M=1.0
C10233 VD 3  106.6266E-18 M=1.0
C10234 703 898  34.9776E-18 M=1.0
C10235 703 717  100.0224E-18 M=1.0
C10236 702 897  34.9776E-18 M=1.0
C10237 663 898  34.9776E-18 M=1.0
C10238 663 717  69.9552E-18 M=1.0
C10239 663 703  100.0224E-18 M=1.0
C10240 662 897  34.9776E-18 M=1.0
C10241 662 702  100.0224E-18 M=1.0
C10242 652 886  34.9776E-18 M=1.0
C10243 648 703  100.0224E-18 M=1.0
C10244 648 663  100.0224E-18 M=1.0
C10245 624 652  34.9776E-18 M=1.0
C10246 617 652  100.0224E-18 M=1.0
C10247 599 649  65.0448E-18 M=1.0
C10248 599 617  135E-18 M=1.0
C10249 598 648  65.0447999999999E-18 M=1.0
C10250 598 616  135E-18 M=1.0
C10251 548 886  34.9776E-18 M=1.0
C10252 548 624  34.9776E-18 M=1.0
C10253 548 617  100.0224E-18 M=1.0
C10254 548 599  169.9776E-18 M=1.0
C10255 141 617  100.0224E-18 M=1.0
C10256 141 599  204.9552E-18 M=1.0
C10257 109 885  34.9776E-18 M=1.0
C10258 109 623  34.9776E-18 M=1.0
C10259 109 616  100.0224E-18 M=1.0
C10260 109 598  139.9104E-18 M=1.0
C10261 34 616  100.0224E-18 M=1.0
C10262 33 702  100.0224E-18 M=1.0
C10263 33 662  69.9552E-18 M=1.0
C10264 3 885  34.9776E-18 M=1.0
C10265 3 623  34.9776E-18 M=1.0
C10266 3 616  100.0224E-18 M=1.0
C10267 2 702  100.0224E-18 M=1.0
C10268 2 662  100.0224E-18 M=1.0
C10269 GD 703  146.8449E-18 M=1.0
C10270 GD 702  146.8449E-18 M=1.0
C10271 GD 663  230.8167E-18 M=1.0
C10272 GD 662  230.8167E-18 M=1.0
C10273 GD 652  397.0251E-18 M=1.0
C10274 GD 624  65.9681999999999E-18 M=1.0
C10275 GD 623  65.9681999999999E-18 M=1.0
C10276 GD 617  326.322E-18 M=1.0
C10277 GD 616  326.322E-18 M=1.0
C10278 GD 141  12.3060285E-15 M=1.0
C10279 GD 34  15.6617064E-15 M=1.0
C10280 VD 898  65.9682E-18 M=1.0
C10281 VD 897  65.9682E-18 M=1.0
C10282 VD 886  65.9682E-18 M=1.0
C10283 VD 885  65.9682E-18 M=1.0
C10284 VD 548  689.1111E-18 M=1.0
C10285 VD 2  527.5539E-18 M=1.0
C10286 703 718  258.287399999999E-18 M=1.0
C10287 702 717  41.148E-18 M=1.0
C10288 663 718  52.3044E-18 M=1.0
C10289 662 717  249.0534E-18 M=1.0
C10290 652 653  103.5792E-18 M=1.0
C10291 649 653  88.2072E-18 M=1.0
C10292 648 717  52.3044E-18 M=1.0
C10293 648 652  88.2072E-18 M=1.0
C10294 617 653  122.0454E-18 M=1.0
C10295 616 652  122.0454E-18 M=1.0
C10296 599 649  118.854E-18 M=1.0
C10297 598 652  144.4914E-18 M=1.0
C10298 598 648  116.5779E-18 M=1.0
C10299 548 653  219.8412E-18 M=1.0
C10300 141 653  175.3056E-18 M=1.0
C10301 109 652  134.5482E-18 M=1.0
C10302 34 652  129.2166E-18 M=1.0
C10303 3 652  208.9368E-18 M=1.0
C10304 2 33  104.6088E-18 M=1.0
C10305 GD 652  848.3913E-18 M=1.0
C10306 GD 649  569.5704E-18 M=1.0
C10307 GD 648  609.4476E-18 M=1.0
C10308 VD 717  198.8757E-18 M=1.0
C10309 VD 653  503.93475E-18 M=1.0
C10310 VD 648  154.79595E-18 M=1.0
C10311 VD 33  198.8757E-18 M=1.0
C10312 GD 769  91.1411999999987E-18 M=1.0
C10313 GD 768  76.2128999999996E-18 M=1.0
C10314 GD 767  70.713E-18 M=1.0
C10315 GD 766  91.1412000000012E-18 M=1.0
C10316 GD 765  76.2129000000016E-18 M=1.0
C10317 GD 764  70.7130000000008E-18 M=1.0
C10318 GD 740  70.713E-18 M=1.0
C10319 GD 739  76.2129E-18 M=1.0
C10320 GD 738  91.1411999999987E-18 M=1.0
C10321 GD 737  84.0699000000005E-18 M=1.0
C10322 GD 736  70.7130000000008E-18 M=1.0
C10323 GD 735  76.2129E-18 M=1.0
C10324 GD 733  84.0699000000005E-18 M=1.0
C10325 GD 706  84.0698999999988E-18 M=1.0
C10326 GD 664  84.0699000000021E-18 M=1.0
C10327 767 768  171.7443E-18 M=1.0
C10328 764 765  171.7443E-18 M=1.0
C10329 745 767  75.2328E-18 M=1.0
C10330 745 764  75.2328E-18 M=1.0
C10331 739 740  171.7443E-18 M=1.0
C10332 737 767  75.2328E-18 M=1.0
C10333 735 736  171.7443E-18 M=1.0
C10334 733 764  75.2328E-18 M=1.0
C10335 719 740  75.2328E-18 M=1.0
C10336 719 736  75.2328E-18 M=1.0
C10337 706 736  75.2328E-18 M=1.0
C10338 664 740  75.2328E-18 M=1.0
C10339 GD 769  202.6413E-18 M=1.0
C10340 GD 768  226.873799999999E-18 M=1.0
C10341 GD 767  250.783200000001E-18 M=1.0
C10342 GD 766  202.6413E-18 M=1.0
C10343 GD 765  226.8738E-18 M=1.0
C10344 GD 764  250.783199999999E-18 M=1.0
C10345 GD 740  250.783200000001E-18 M=1.0
C10346 GD 739  226.8738E-18 M=1.0
C10347 GD 738  202.6413E-18 M=1.0
C10348 GD 737  194.3694E-18 M=1.0
C10349 GD 736  250.783200000001E-18 M=1.0
C10350 GD 735  226.8738E-18 M=1.0
C10351 GD 734  202.6413E-18 M=1.0
C10352 GD 706  191.6757E-18 M=1.0
C10353 GD 664  191.6757E-18 M=1.0
C10354 S_3 GD  183.8277E-18 M=1.0
C10355 S_2 GD  183.8277E-18 M=1.0
C10356 VD 769  30.4272000000001E-18 M=1.0
C10357 VD 768  30.4272000000001E-18 M=1.0
C10358 VD 767  45.4922999999999E-18 M=1.0
C10359 VD 766  30.4272000000001E-18 M=1.0
C10360 VD 765  30.4272000000001E-18 M=1.0
C10361 VD 740  45.4923000000001E-18 M=1.0
C10362 VD 739  30.4272000000001E-18 M=1.0
C10363 VD 738  30.4272000000001E-18 M=1.0
C10364 VD 737  50.8401000000001E-18 M=1.0
C10365 VD 736  45.4922999999997E-18 M=1.0
C10366 VD 735  30.4271999999998E-18 M=1.0
C10367 VD 734  30.4272000000001E-18 M=1.0
C10368 VD 733  50.8401000000001E-18 M=1.0
C10369 VD 706  50.8401E-18 M=1.0
C10370 VD 664  50.8401E-18 M=1.0
C10371 VD S_3  30.4272000000001E-18 M=1.0
C10372 VD S_2  30.4271999999998E-18 M=1.0
C10373 745 768  74.9664E-18 M=1.0
C10374 745 767  117.0432E-18 M=1.0
C10375 745 765  74.9664E-18 M=1.0
C10376 745 764  117.0432E-18 M=1.0
C10377 737 767  179.1504E-18 M=1.0
C10378 737 745  80.6040000000001E-18 M=1.0
C10379 719 740  201.1455E-18 M=1.0
C10380 719 739  74.9664E-18 M=1.0
C10381 719 736  117.0432E-18 M=1.0
C10382 719 735  74.9664E-18 M=1.0
C10383 706 719  42.0768E-18 M=1.0
C10384 664 719  104.4144E-18 M=1.0
C10385 GD 737  180.4824E-18 M=1.0
C10386 GD 719  1.93558455E-15 M=1.0
C10387 VD 737  348.4404E-18 M=1.0
C10388 VD 719  197.8191E-18 M=1.0
C10389 745 769  69.741E-18 M=1.0
C10390 745 767  54.3294E-18 M=1.0
C10391 745 766  69.741E-18 M=1.0
C10392 737 745  25.6374E-18 M=1.0
C10393 719 740  59.5152E-18 M=1.0
C10394 719 739  25.3224E-18 M=1.0
C10395 719 738  69.741E-18 M=1.0
C10396 719 737  67.9203E-18 M=1.0
C10397 719 736  59.5152E-18 M=1.0
C10398 719 735  25.3224E-18 M=1.0
C10399 719 734  69.741E-18 M=1.0
C10400 706 719  25.6374E-18 M=1.0
C10401 655 740  72.5913E-18 M=1.0
C10402 GD 745  1.656322875E-15 M=1.0
C10403 S_3 745  44.1036E-18 M=1.0
C10404 S_2 745  44.1036E-18 M=1.0
C10405 GD 762  76.2129000000002E-18 M=1.0
C10406 GD 761  70.7129999999996E-18 M=1.0
C10407 GD 760  91.1411999999985E-18 M=1.0
C10408 GD 759  76.2129000000002E-18 M=1.0
C10409 GD 758  70.713000000001E-18 M=1.0
C10410 GD 732  70.713E-18 M=1.0
C10411 GD 731  76.2129E-18 M=1.0
C10412 GD 730  91.1412000000014E-18 M=1.0
C10413 GD 729  84.0699000000005E-18 M=1.0
C10414 GD 728  70.7130000000006E-18 M=1.0
C10415 GD 727  76.212899999999E-18 M=1.0
C10416 GD 726  91.1412000000014E-18 M=1.0
C10417 GD 725  84.0698999999988E-18 M=1.0
C10418 GD 719  742.486500000005E-18 M=1.0
C10419 GD 1  84.0698999999988E-18 M=1.0
C10420 VD 745  133.568999999999E-18 M=1.0
C10421 761 762  171.7443E-18 M=1.0
C10422 758 759  171.7443E-18 M=1.0
C10423 745 761  75.2327999999998E-18 M=1.0
C10424 745 758  75.2328E-18 M=1.0
C10425 731 732  171.7443E-18 M=1.0
C10426 729 761  75.2328E-18 M=1.0
C10427 727 728  171.7443E-18 M=1.0
C10428 725 758  75.2328E-18 M=1.0
C10429 719 732  75.2328E-18 M=1.0
C10430 719 728  75.2328E-18 M=1.0
C10431 705 732  75.2328E-18 M=1.0
C10432 1 728  75.2328E-18 M=1.0
C10433 GD 763  202.6413E-18 M=1.0
C10434 GD 762  226.8738E-18 M=1.0
C10435 GD 761  250.783199999999E-18 M=1.0
C10436 GD 760  202.6413E-18 M=1.0
C10437 GD 759  226.873800000001E-18 M=1.0
C10438 GD 758  250.783200000001E-18 M=1.0
C10439 GD 745  439.872750000001E-18 M=1.0
C10440 GD 731  226.8738E-18 M=1.0
C10441 GD 730  202.6413E-18 M=1.0
C10442 GD 729  194.369400000001E-18 M=1.0
C10443 GD 728  250.783200000001E-18 M=1.0
C10444 GD 727  226.8738E-18 M=1.0
C10445 GD 726  202.641299999999E-18 M=1.0
C10446 GD 725  194.369400000001E-18 M=1.0
C10447 GD 705  191.6757E-18 M=1.0
C10448 GD 1  71.1873000000001E-18 M=1.0
C10449 VD 763  30.4271999999998E-18 M=1.0
C10450 VD 762  30.4272000000001E-18 M=1.0
C10451 VD 761  45.4923000000001E-18 M=1.0
C10452 VD 760  30.4272000000001E-18 M=1.0
C10453 VD 759  30.4272000000001E-18 M=1.0
C10454 VD 758  45.4922999999999E-18 M=1.0
C10455 VD 731  30.4272000000001E-18 M=1.0
C10456 VD 730  30.4272000000001E-18 M=1.0
C10457 VD 729  50.8401000000002E-18 M=1.0
C10458 VD 728  45.4923000000005E-18 M=1.0
C10459 VD 727  30.4272000000001E-18 M=1.0
C10460 VD 726  30.4272000000001E-18 M=1.0
C10461 VD 725  50.8401000000002E-18 M=1.0
C10462 VD 705  50.8400999999998E-18 M=1.0
C10463 S_0 GD  183.827700000001E-18 M=1.0
C10464 S_0 VD  30.4272000000001E-18 M=1.0
C10465 745 762  74.9664000000001E-18 M=1.0
C10466 745 761  117.0432E-18 M=1.0
C10467 745 759  74.9664000000001E-18 M=1.0
C10468 745 758  117.0432E-18 M=1.0
C10469 729 761  177.498E-18 M=1.0
C10470 729 745  80.604E-18 M=1.0
C10471 725 758  174.6027E-18 M=1.0
C10472 725 745  80.604E-18 M=1.0
C10473 719 732  117.0432E-18 M=1.0
C10474 719 731  74.9664E-18 M=1.0
C10475 719 728  117.0432E-18 M=1.0
C10476 719 727  74.9664000000001E-18 M=1.0
C10477 1 719  42.0768E-18 M=1.0
C10478 GD 745  1.66077E-15 M=1.0
C10479 GD 729  269.84205E-18 M=1.0
C10480 GD 725  156.8466E-18 M=1.0
C10481 VD 729  351.5607E-18 M=1.0
C10482 VD 725  348.4404E-18 M=1.0
C10483 VD 1  21.0987E-18 M=1.0
C10484 745 761  54.3294E-18 M=1.0
C10485 745 760  69.741E-18 M=1.0
C10486 729 745  25.6374E-18 M=1.0
C10487 719 731  25.3224E-18 M=1.0
C10488 719 730  69.741E-18 M=1.0
C10489 719 729  77.1003E-18 M=1.0
C10490 719 728  44.1036E-18 M=1.0
C10491 1 719  25.6374E-18 M=1.0
C10492 VD 705  169.78995E-18 M=1.0
C10493 VD 1  184.52115E-18 M=1.0
C10494 S_0 745  44.1036E-18 M=1.0
M10495 866 536 467 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=400.949998029254E-15 PD=1.7999999499807E-6
+PS=989.999989542412E-9 M=1
M10496 467 586 866 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=218.700003853239E-15 PD=989.999989542412E-9
+PS=539.999973625527E-9 M=1
M10497 866 457 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10498 VD 445 866 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M10499 457 536 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10500 445 586 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10501 288 142 835 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=218.700003853239E-15 PD=1.07999994725105E-6
+PS=539.999973625527E-9 M=1
M10502 289 322 834 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M10503 835 280 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10504 834 227 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M10505 VD 246 835 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M10506 VD 105 834 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10507 834 171 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10508 280 164 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=1.70999999227206E-6
+PS=1.97999997908482E-6 M=1
M10509 279 200 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M10510 278 199 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M10511 VD 289 247 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M10512 246 142 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10513 245 234 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M10514 244 233 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M10515 VD 322 243 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M10516 VD 38 831 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10517 VD 166 830 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10518 831 7 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10519 830 144 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10520 VD 113 831 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M10521 VD 134 830 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M10522 831 200 234 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M10523 830 199 233 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M10524 819 A7B3 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M10525 VD A7B3 1332 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10526 1332 A6B4 202 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M10527 202 138 819 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M10528 819 A6B4 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M10529 VD A6B4 1326 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10530 1326 A7B3 1323 VD  TSMC18DP  L=180.000000682412E-9
+W=810.000017281709E-9 AD=182.249994176015E-15 AS=200.474999014627E-15
+PD=449.999987495175E-9 PS=494.999994771206E-9 M=1
M10531 1323 138 197 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M10532 197 202 804 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M10533 804 138 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M10534 VD A7B3 804 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10535 804 A6B4 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10536 VD 197 171 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M10537 VD 202 170 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M10538 169 161 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10539 168 160 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10540 167 159 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10541 166 158 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10542 165 157 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10543 164 156 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10544 A7B4 163 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10545 A6B4 162 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10546 VD 419 158 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10547 VD 419 157 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10548 VD 419 156 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10549 VD 419 163 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10550 VD 419 162 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10551 VD 419 161 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10552 VD 419 160 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10553 VD 419 159 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10554 163 338 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10555 162 342 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10556 161 346 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10557 160 350 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10558 159 354 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10559 158 358 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10560 157 362 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10561 156 A0ININ VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10562 140 132 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10563 139 131 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10564 138 130 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10565 137 129 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10566 136 128 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10567 135 127 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10568 134 126 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10569 133 125 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10570 VD 423 131 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10571 VD 423 130 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10572 VD 423 129 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10573 VD 423 128 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10574 VD 423 127 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10575 VD 423 126 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10576 VD 423 125 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10577 VD 423 132 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10578 128 354 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10579 127 358 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10580 126 362 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10581 125 A0ININ VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10582 132 338 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10583 131 342 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10584 130 346 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10585 129 350 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10586 103 95 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10587 102 94 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10588 101 93 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10589 108 100 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10590 107 99 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10591 106 98 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10592 105 97 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10593 104 96 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10594 VD 427 100 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10595 VD 427 99 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10596 VD 427 98 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10597 VD 427 97 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10598 VD 427 96 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10599 VD 427 95 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10600 VD 427 94 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10601 VD 427 93 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10602 100 338 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10603 99 342 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10604 98 346 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10605 97 350 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10606 96 354 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10607 95 358 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10608 94 362 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10609 93 A0ININ VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10610 31 23 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10611 30 22 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10612 29 21 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10613 28 20 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10614 27 19 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10615 26 18 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10616 25 17 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10617 32 24 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10618 VD 431 20 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10619 VD 431 19 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10620 VD 431 18 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10621 VD 431 17 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10622 VD 431 24 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10623 VD 431 23 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10624 VD 431 22 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10625 VD 431 21 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10626 17 A0ININ VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10627 24 338 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10628 23 342 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10629 22 346 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10630 21 350 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10631 20 354 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10632 19 358 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10633 18 362 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10634 234 113 1334 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M10635 233 134 1333 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M10636 1334 7 1331 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M10637 1333 144 1330 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M10638 1331 38 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M10639 1330 166 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M10640 VD 38 806 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M10641 VD 166 805 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M10642 806 113 200 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M10643 805 134 199 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M10644 200 38 1325 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M10645 199 166 1324 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M10646 1325 7 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M10647 1324 144 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M10648 VD 7 806 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M10649 VD 144 805 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M10650 VD 338 155 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10651 VD 342 154 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10652 VD 346 153 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10653 VD 350 152 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10654 VD 354 151 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10655 VD 358 150 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10656 VD 362 149 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10657 VD A0ININ 148 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10658 152 415 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10659 151 415 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10660 150 415 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10661 149 415 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10662 148 415 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10663 155 415 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10664 154 415 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10665 153 415 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10666 VD 149 142 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10667 VD 148 141 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10668 VD 155 A7B3 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10669 VD 154 147 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10670 VD 153 146 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10671 VD 152 145 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10672 VD 151 144 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10673 VD 150 143 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10674 VD A0ININ 117 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10675 VD 338 124 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10676 VD 342 123 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10677 VD 346 122 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10678 VD 350 121 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10679 VD 354 120 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10680 VD 358 119 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10681 VD 362 118 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10682 124 411 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10683 123 411 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10684 122 411 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10685 121 411 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10686 120 411 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10687 119 411 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10688 118 411 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10689 117 411 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10690 VD 122 114 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10691 VD 121 113 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10692 VD 120 112 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10693 VD 119 111 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10694 VD 118 110 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10695 VD 117 109 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10696 VD 124 116 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10697 VD 123 115 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10698 VD 350 89 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10699 VD 354 44 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10700 VD 358 43 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10701 VD 362 42 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10702 VD A0ININ 41 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10703 VD 338 92 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10704 VD 342 91 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10705 VD 346 90 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10706 42 407 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10707 41 407 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10708 92 407 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10709 91 407 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10710 90 407 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10711 89 407 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10712 44 407 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10713 43 407 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10714 VD 92 40 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10715 VD 91 39 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10716 VD 90 38 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10717 VD 89 37 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10718 VD 44 36 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10719 VD 43 35 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10720 VD 42 34 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10721 VD 41 33 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10722 VD 338 16 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10723 VD 342 15 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10724 VD 346 14 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10725 VD 350 13 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10726 VD 354 12 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10727 VD 358 11 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10728 VD 362 10 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10729 VD A0ININ 9 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10730 14 403 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10731 13 403 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10732 12 403 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10733 11 403 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10734 10 403 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10735 9 403 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10736 16 403 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10737 15 403 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10738 VD 11 3 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10739 VD 10 2 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10740 VD 9 1 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10741 VD 16 8 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10742 VD 15 7 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10743 VD 14 6 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10744 VD 13 5 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10745 VD 12 4 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10746 724 721 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10747 723 721 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10748 VD A7B4 650 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10749 VD 139 626 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.97999997908482E-6
+PS=1.70999999227206E-6 M=1
M10750 628 402 1450 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M10751 1450 605 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M10752 884 650 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=218.700003853239E-15 PD=1.7999999499807E-6
+PS=539.999973625527E-9 M=1
M10753 VD 402 625 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10754 VD 626 884 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10755 VD 32 620 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10756 884 A7B4 621 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=437.400007706479E-15 PD=539.999973625527E-9
+PS=1.07999994725105E-6 M=1
M10757 VD 625 615 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10758 VD 521 614 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.97999997908482E-6
+PS=1.70999999227206E-6 M=1
M10759 621 139 884 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=400.949998029254E-15 PD=1.07999994725105E-6
+PS=1.7999999499807E-6 M=1
M10760 VD 615 610 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M10761 882 620 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=218.700003853239E-15 PD=1.7999999499807E-6
+PS=539.999973625527E-9 M=1
M10762 VD A7B4 608 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10763 VD 614 882 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10764 608 139 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10765 882 32 605 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=437.400007706479E-15 PD=539.999973625527E-9
+PS=1.07999994725105E-6 M=1
M10766 604 402 1445 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M10767 VD 608 596 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10768 1445 564 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M10769 VD 108 595 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10770 605 521 882 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=400.949998029254E-15 PD=1.07999994725105E-6
+PS=1.7999999499807E-6 M=1
M10771 VD 402 592 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10772 VD 32 575 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10773 VD 31 574 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.97999997908482E-6
+PS=1.70999999227206E-6 M=1
M10774 VD 592 567 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10775 575 521 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10776 878 595 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=218.700003853239E-15 PD=1.7999999499807E-6
+PS=539.999973625527E-9 M=1
M10777 877 140 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M10778 VD 575 564 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10779 VD 574 878 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10780 VD 567 561 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M10781 VD 140 1441 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10782 878 108 563 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=437.400007706479E-15 PD=539.999973625527E-9
+PS=1.07999994725105E-6 M=1
M10783 1441 107 554 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M10784 563 31 878 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=400.949998029254E-15 PD=1.07999994725105E-6
+PS=1.7999999499807E-6 M=1
M10785 554 596 877 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M10786 553 402 1436 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M10787 877 107 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M10788 1436 460 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M10789 VD 108 546 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10790 873 563 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M10791 VD 107 1434 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10792 VD 402 541 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10793 546 31 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10794 VD 563 1433 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10795 1434 140 1432 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M10796 1433 485 522 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M10797 1432 596 520 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M10798 VD 546 521 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10799 VD 541 514 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10800 522 436 873 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M10801 520 554 872 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M10802 873 485 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M10803 VD 514 505 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M10804 872 596 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M10805 VD 485 1431 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10806 VD 140 872 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10807 1431 563 1426 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M10808 872 107 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10809 1426 436 497 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M10810 VD 494 499 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10811 VD 520 494 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M10812 501 402 1417 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M10813 1417 454 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M10814 497 522 870 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M10815 VD 377 492 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.97999997908482E-6
+PS=1.70999999227206E-6 M=1
M10816 VD 402 493 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10817 VD 554 485 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M10818 870 436 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M10819 863 499 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=218.700003853239E-15 PD=1.7999999499807E-6
+PS=539.999973625527E-9 M=1
M10820 VD 563 870 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10821 VD 493 468 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10822 VD 492 863 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10823 870 485 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10824 863 494 470 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=437.400007706479E-15 PD=539.999973625527E-9
+PS=1.07999994725105E-6 M=1
M10825 VD 497 460 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M10826 VD 468 459 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M10827 470 377 863 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=400.949998029254E-15 PD=1.07999994725105E-6
+PS=1.7999999499807E-6 M=1
M10828 VD 522 454 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M10829 862 621 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M10830 VD 621 1411 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10831 VD 494 453 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10832 1411 106 442 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M10833 453 377 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10834 442 170 862 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M10835 VD 453 436 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10836 862 106 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M10837 857 470 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M10838 VD 106 1406 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10839 VD 470 1405 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10840 1406 621 1404 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M10841 1405 367 401 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M10842 1404 170 400 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M10843 401 30 857 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M10844 VD 383 394 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10845 400 442 856 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M10846 857 367 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M10847 856 170 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M10848 VD 367 1403 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10849 VD 243 386 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.97999997908482E-6
+PS=1.70999999227206E-6 M=1
M10850 VD 621 856 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10851 1403 470 1398 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M10852 856 106 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10853 1398 30 384 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M10854 855 394 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=218.700003853239E-15 PD=1.7999999499807E-6
+PS=539.999973625527E-9 M=1
M10855 VD 400 383 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M10856 VD 386 855 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10857 384 401 854 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M10858 855 383 382 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=437.400007706479E-15 PD=539.999973625527E-9
+PS=1.07999994725105E-6 M=1
M10859 VD 442 377 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M10860 854 30 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M10861 382 243 855 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=400.949998029254E-15 PD=1.07999994725105E-6
+PS=1.7999999499807E-6 M=1
M10862 VD 470 854 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10863 854 367 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10864 VD 383 374 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10865 VD 384 368 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M10866 374 243 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10867 VD 401 366 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M10868 849 105 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M10869 VD 374 367 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10870 VD 105 1373 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10871 1373 171 322 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M10872 322 227 849 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M10873 849 171 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M10874 VD 171 1372 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M10875 1372 105 1371 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M10876 1371 227 289 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M10877 618 613 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M10878 VD 627 611 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10879 CLK_EN 607 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10880 1449 548 1447 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M10881 1448 3 1446 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M10882 609 549 883 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=218.700003853239E-15 PD=1.07999994725105E-6
+PS=539.999973625527E-9 M=1
M10883 1446 34 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M10884 611 550 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10885 1447 141 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M10886 613 603 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10887 883 597 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10888 VD 141 880 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M10889 VD 34 879 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M10890 VD 570 607 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10891 VD 587 883 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M10892 881 627 594 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=437.400007706479E-15 PD=1.7999999499807E-6
+PS=1.07999994725105E-6 M=1
M10893 880 652 599 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M10894 879 109 598 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M10895 603 388 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10896 607 CLK VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10897 VD 704 1444 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M10898 597 653 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=1.70999999227206E-6
+PS=1.97999997908482E-6 M=1
M10899 594 550 881 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=218.700003853239E-15 PD=1.07999994725105E-6
+PS=539.999973625527E-9 M=1
M10900 599 141 1443 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M10901 598 34 1442 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M10902 1444 388 589 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M10903 881 568 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10904 1443 548 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M10905 1442 3 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M10906 VD 562 881 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M10907 587 549 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10908 VD 548 880 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M10909 VD 3 879 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M10910 588 569 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M10911 568 627 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=1.70999999227206E-6
+PS=1.97999997908482E-6 M=1
M10912 571 565 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M10913 569 559 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10914 570 560 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=364.499988352029E-15 PD=1.7999999499807E-6
+PS=1.70999999227206E-6 M=1
M10915 562 550 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10916 565 552 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10917 559 606 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10918 552 388 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10919 VD 594 1435 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M10920 1435 388 539 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M10921 523 509 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M10922 509 500 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10923 500 388 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10924 VD 540 1416 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M10925 1416 388 491 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M10926 472 461 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M10927 461 452 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10928 452 388 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10929 VD 498 1407 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M10930 1407 388 440 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M10931 VD 619 1440 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M10932 560 566 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10933 1440 606 547 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M10934 538 519 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M10935 537 518 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M10936 525 511 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10937 524 510 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10938 519 504 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10939 518 503 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10940 VD 467 511 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10941 VD 525 510 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10942 504 555 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10943 503 606 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10944 511 466 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10945 510 465 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10946 VD 292 1422 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M10947 VD 447 1421 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M10948 1422 555 496 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M10949 1421 606 495 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M10950 865 533 466 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=400.949998029254E-15 PD=1.7999999499807E-6
+PS=989.999989542412E-9 M=1
M10951 864 582 465 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=400.949998029254E-15 PD=1.7999999499807E-6
+PS=989.999989542412E-9 M=1
M10952 489 471 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M10953 466 477 865 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=218.700003853239E-15 PD=989.999989542412E-9
+PS=539.999973625527E-9 M=1
M10954 465 538 864 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=218.700003853239E-15 PD=989.999989542412E-9
+PS=539.999973625527E-9 M=1
M10955 471 458 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10956 865 456 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10957 864 455 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10958 VD 444 865 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M10959 VD 443 864 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M10960 458 606 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10961 VD 435 1412 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M10962 456 533 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10963 455 582 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10964 1412 606 446 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M10965 444 477 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10966 443 538 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10967 558 490 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M10968 557 488 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M10969 556 487 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M10970 550 508 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M10971 549 507 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M10972 548 506 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M10973 VD 283 876 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10974 VD 288 875 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10975 VD 35 874 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10976 540 513 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M10977 876 437 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10978 875 439 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10979 874 4 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M10980 VD 557 876 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M10981 VD 556 875 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M10982 VD 110 874 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M10983 VD 558 513 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M10984 513 438 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M10985 876 490 508 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M10986 875 488 507 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M10987 874 487 506 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M10988 871 558 498 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=437.400007706479E-15 PD=1.7999999499807E-6
+PS=1.07999994725105E-6 M=1
M10989 508 557 1429 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M10990 507 556 1428 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M10991 506 110 1427 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M10992 1429 437 1425 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M10993 1428 439 1424 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M10994 1427 4 1423 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M10995 498 438 871 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=218.700003853239E-15 PD=1.07999994725105E-6
+PS=539.999973625527E-9 M=1
M10996 1425 283 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M10997 1424 288 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M10998 1423 35 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M10999 871 486 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11000 VD 283 869 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11001 VD 288 868 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11002 VD 35 867 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11003 VD 469 871 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M11004 869 557 490 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11005 868 556 488 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11006 867 110 487 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11007 486 558 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=1.70999999227206E-6
+PS=1.97999997908482E-6 M=1
M11008 490 283 1415 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11009 488 288 1414 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11010 487 35 1413 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11011 1415 437 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11012 1414 439 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11013 1413 4 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11014 VD 437 869 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11015 469 438 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11016 VD 439 868 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11017 VD 4 867 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11018 450 381 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11019 449 380 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11020 448 379 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11021 447 378 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11022 439 392 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11023 438 391 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11024 437 390 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11025 435 389 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11026 VD 36 861 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11027 VD 330 860 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11028 VD 323 859 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11029 VD 204 858 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11030 861 5 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11031 860 326 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11032 859 236 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11033 858 249 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11034 VD 111 861 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11035 VD 448 860 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11036 VD 450 859 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11037 VD 449 858 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11038 861 381 392 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11039 860 380 391 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11040 859 379 390 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11041 858 378 389 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11042 392 111 1402 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11043 391 448 1401 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11044 390 450 1400 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11045 389 449 1399 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11046 1402 5 1389 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11047 1401 326 1388 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11048 1400 236 1387 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11049 1399 249 1386 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11050 1389 36 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11051 1388 330 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11052 1387 323 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11053 1386 204 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11054 VD 36 853 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11055 VD 330 852 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11056 VD 323 851 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11057 VD 204 850 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11058 853 111 381 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11059 852 448 380 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11060 851 450 379 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11061 850 449 378 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11062 381 36 1377 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11063 380 330 1376 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11064 379 323 1375 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11065 378 204 1374 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11066 1377 5 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11067 1376 326 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11068 1375 236 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11069 1374 249 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11070 VD 5 853 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11071 VD 326 852 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11072 VD 236 851 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11073 VD 249 850 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11074 323 290 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11075 VD 164 290 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11076 290 142 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11077 835 164 288 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=437.400007706479E-15 PD=1.7999999499807E-6
+PS=1.07999994725105E-6 M=1
M11078 722 721 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11079 721 720 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11080 720 593 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11081 719 716 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11082 718 715 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11083 717 714 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11084 VD 717 715 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11085 VD 33 714 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11086 716 606 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11087 715 648 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11088 714 2 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11089 713 707 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11090 898 717 706 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=437.400007706479E-15 PD=1.7999999499807E-6
+PS=1.07999994725105E-6 M=1
M11091 897 33 705 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=437.400007706479E-15 PD=1.7999999499807E-6
+PS=1.07999994725105E-6 M=1
M11092 VD 718 707 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11093 706 648 898 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=218.700003853239E-15 PD=1.07999994725105E-6
+PS=539.999973625527E-9 M=1
M11094 705 2 897 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=218.700003853239E-15 PD=1.07999994725105E-6
+PS=539.999973625527E-9 M=1
M11095 707 649 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11096 898 703 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11097 897 702 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11098 704 683 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11099 VD 663 898 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M11100 VD 662 897 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M11101 895 718 664 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=437.400007706479E-15 PD=1.7999999499807E-6
+PS=1.07999994725105E-6 M=1
M11102 VD 713 683 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11103 664 649 895 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=218.700003853239E-15 PD=1.07999994725105E-6
+PS=539.999973625527E-9 M=1
M11104 703 717 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=1.70999999227206E-6
+PS=1.97999997908482E-6 M=1
M11105 702 33 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=1.70999999227206E-6
+PS=1.97999997908482E-6 M=1
M11106 683 609 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11107 895 656 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11108 VD 654 895 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M11109 663 648 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11110 662 2 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11111 888 713 655 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=437.400007706479E-15 PD=1.7999999499807E-6
+PS=1.07999994725105E-6 M=1
M11112 656 718 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=1.70999999227206E-6
+PS=1.97999997908482E-6 M=1
M11113 655 609 888 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=218.700003853239E-15 PD=1.07999994725105E-6
+PS=539.999973625527E-9 M=1
M11114 888 651 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11115 VD 647 888 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M11116 654 649 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11117 653 599 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11118 652 598 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11119 651 713 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=1.70999999227206E-6
+PS=1.97999997908482E-6 M=1
M11120 647 609 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11121 649 617 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11122 648 616 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11123 VD 141 886 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11124 VD 34 885 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11125 627 622 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11126 886 548 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11127 885 3 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11128 VD 652 886 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11129 VD 109 885 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11130 VD 653 622 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11131 622 549 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11132 885 598 616 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11133 886 599 617 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11134 619 611 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11135 883 653 609 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=437.400007706479E-15 PD=1.7999999499807E-6
+PS=1.07999994725105E-6 M=1
M11136 617 652 1449 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11137 616 109 1448 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11138 S_7 781 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11139 695 691 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11140 1454 695 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11141 VD 695 891 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11142 VD 593 590 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11143 VD 543 542 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11144 418 387 1393 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11145 1393 B_3 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11146 VD 387 417 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11147 350 349 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11148 349 348 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11149 VD 295 293 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11150 303 254 839 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11151 313 315 842 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11152 VD 297 292 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11153 839 261 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11154 842 266 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11155 845 104 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11156 VD 261 1357 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11157 VD 29 842 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11158 VD 104 1367 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11159 1357 317 1356 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11160 842 382 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11161 1367 27 321 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11162 1356 254 301 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11163 VD 313 311 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11164 321 116 845 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11165 301 303 838 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11166 VD 315 310 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11167 845 27 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11168 838 254 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11169 841 267 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11170 VD 27 1366 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11171 VD 317 838 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11172 VD 267 1361 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11173 1366 104 1365 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11174 838 261 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11175 1361 28 309 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11176 1365 116 319 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11177 VD 301 299 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11178 309 260 841 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11179 319 321 844 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11180 VD 303 298 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11181 841 28 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11182 844 116 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11183 837 255 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11184 VD 28 1360 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11185 VD 104 844 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11186 VD 255 1355 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11187 1360 267 1359 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11188 844 27 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11189 1355 222 297 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11190 1359 260 307 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11191 VD 319 317 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11192 297 248 837 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11193 307 309 840 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11194 VD 321 316 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11195 837 222 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11196 840 260 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11197 843 29 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11198 VD 222 1354 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11199 VD 267 840 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11200 VD 29 1364 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11201 1354 255 1353 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11202 840 28 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11203 1364 382 315 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11204 1353 248 295 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11205 VD 307 305 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11206 315 266 843 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11207 295 297 836 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11208 VD 309 304 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11209 843 382 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11210 836 248 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11211 839 317 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11212 VD 382 1363 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11213 VD 255 836 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11214 VD 317 1358 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11215 1363 29 1362 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11216 836 222 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11217 1358 261 303 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11218 1362 266 313 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11219 1350 133 285 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11220 285 287 832 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11221 832 133 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11222 VD 143 832 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11223 832 165 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11224 VD 285 283 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11225 VD 287 282 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11226 833 143 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11227 VD 143 1352 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11228 1352 165 287 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11229 287 133 833 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11230 833 165 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11231 VD 165 1351 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11232 1351 143 1350 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11233 1337 329 253 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11234 1341 215 263 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11235 VD 275 273 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11236 253 324 821 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11237 263 265 824 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11238 VD 277 272 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11239 821 329 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11240 824 215 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11241 827 316 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11242 VD 329 1336 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11243 VD 273 824 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11244 VD 316 1346 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11245 1336 210 1335 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11246 824 221 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11247 1346 247 271 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11248 1335 324 251 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11249 VD 263 261 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11250 271 272 827 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11251 251 253 820 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11252 VD 265 260 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11253 827 247 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11254 820 324 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11255 823 216 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11256 VD 247 1345 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11257 VD 210 820 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11258 VD 216 1340 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11259 1345 316 1344 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11260 820 329 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11261 1340 203 259 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11262 1344 272 269 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11263 VD 251 249 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11264 259 209 823 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11265 269 271 826 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11266 VD 253 248 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11267 823 203 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11268 826 272 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11269 829 228 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11270 VD 203 1339 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11271 VD 316 826 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11272 VD 228 1349 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11273 1339 216 1338 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11274 826 247 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11275 1349 190 277 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11276 1338 209 257 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11277 VD 269 267 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11278 277 185 829 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11279 257 259 822 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11280 VD 271 266 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11281 829 190 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11282 822 209 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11283 825 273 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11284 VD 190 1348 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11285 VD 216 822 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11286 VD 273 1343 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11287 1348 228 1347 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11288 822 203 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11289 1343 221 265 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11290 1347 185 275 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11291 VD 257 255 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11292 265 215 825 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11293 275 277 828 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11294 VD 259 254 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11295 825 221 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11296 828 185 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11297 821 210 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11298 VD 221 1342 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11299 VD 228 828 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11300 VD 210 1337 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11301 1342 273 1341 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11302 828 190 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11303 208 174 808 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11304 808 102 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11305 VD 102 1309 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11306 1309 25 1308 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11307 178 135 798 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11308 798 167 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11309 VD 167 1300 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11310 1300 145 1299 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11311 VD 26 1318 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11312 1318 103 1317 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11313 1317 187 224 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11314 224 226 813 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11315 813 187 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11316 816 147 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11317 VD 103 813 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11318 VD 147 1322 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11319 813 26 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11320 1322 169 232 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11321 VD 224 222 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11322 232 137 816 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11323 VD 226 221 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11324 816 169 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11325 812 191 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11326 VD 169 1321 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11327 VD 191 1316 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11328 1321 147 1320 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11329 1316 179 220 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11330 1320 137 230 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11331 220 173 812 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11332 230 232 815 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11333 812 179 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11334 815 137 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11335 VD 179 1315 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11336 VD 147 815 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11337 1315 191 1314 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11338 815 169 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11339 1314 173 218 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11340 VD 230 228 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11341 218 220 811 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11342 VD 232 227 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11343 811 173 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11344 814 103 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11345 VD 191 811 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11346 VD 103 1319 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11347 811 179 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11348 1319 26 226 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11349 VD 218 216 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11350 226 187 814 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11351 VD 220 215 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11352 814 26 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11353 808 25 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11354 VD 25 1310 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11355 1310 102 208 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11356 VD 146 802 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11357 802 168 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11358 VD 193 191 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11359 VD 195 190 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11360 VD 40 189 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11361 VD 115 188 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.97999997908482E-6
+PS=1.70999999227206E-6 M=1
M11362 799 189 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=218.700003853239E-15 PD=1.7999999499807E-6
+PS=539.999973625527E-9 M=1
M11363 VD 188 799 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11364 799 40 187 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=437.400007706479E-15 PD=539.999973625527E-9
+PS=1.07999994725105E-6 M=1
M11365 187 115 799 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=400.949998029254E-15 PD=1.07999994725105E-6
+PS=1.7999999499807E-6 M=1
M11366 VD 40 186 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11367 186 115 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11368 VD 186 185 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11369 803 146 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11370 VD 146 1307 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11371 1307 168 195 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11372 195 136 803 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11373 803 168 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11374 VD 168 1306 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11375 1306 146 1305 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11376 1305 136 193 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11377 193 195 802 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11378 802 136 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11379 798 145 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11380 VD 145 1301 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11381 1301 167 178 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11382 818 6 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11383 VD 6 1329 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11384 1329 37 240 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11385 240 112 818 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11386 818 37 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11387 VD 37 1328 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11388 1328 6 1327 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11389 1327 112 238 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11390 238 240 817 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11391 817 112 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11392 VD 6 817 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11393 817 37 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11394 VD 238 236 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11395 VD 240 235 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11396 810 180 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11397 VD 180 1313 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11398 1313 278 214 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11399 214 279 810 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11400 810 278 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11401 VD 278 1312 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11402 1312 180 1311 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11403 1311 279 212 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11404 212 214 809 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11405 809 279 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11406 VD 180 809 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11407 809 278 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11408 VD 212 210 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11409 VD 214 209 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11410 807 174 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11411 VD 25 807 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11412 807 102 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11413 VD 206 204 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11414 VD 208 203 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11415 1308 174 206 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11416 206 208 807 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11417 VD 8 800 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11418 800 39 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11419 VD 182 180 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11420 VD 184 179 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11421 801 8 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11422 VD 8 1304 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11423 1304 39 184 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11424 184 114 801 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11425 801 39 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11426 VD 39 1303 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11427 1303 8 1302 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11428 1302 114 182 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11429 182 184 800 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11430 800 114 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11431 1299 135 176 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11432 176 178 797 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11433 797 135 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11434 VD 145 797 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11435 797 167 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11436 VD 176 174 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11437 VD 178 173 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11438 S_12 796 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11439 796 795 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11440 795 723 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11441 VD 669 1499 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11442 1499 723 794 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11443 S_11 793 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11444 793 792 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11445 792 723 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11446 VD 645 1498 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11447 1498 723 791 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11448 S_10 790 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11449 790 789 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11450 789 723 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11451 VD 688 1497 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11452 1497 723 788 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11453 S_9 787 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11454 787 786 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11455 786 723 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11456 VD 639 1496 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11457 1496 723 785 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11458 S_8 784 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11459 784 783 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11460 783 722 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11461 VD 694 1495 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11462 1495 722 782 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11463 757 756 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11464 756 724 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11465 VD 712 1486 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11466 1486 724 755 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11467 S_15 754 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11468 754 753 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11469 753 724 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11470 VD 710 1485 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11471 1485 724 752 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11472 S_14 751 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11473 751 750 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11474 750 724 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11475 VD 681 1484 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11476 1484 724 749 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11477 S_13 748 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11478 748 747 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11479 747 724 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11480 VD 675 1483 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11481 1483 724 746 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11482 S_16 757 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11483 686 533 1471 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11484 1471 640 1470 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11485 1470 477 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11486 VD 477 905 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11487 905 533 685 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11488 685 477 1469 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11489 1469 640 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11490 VD 640 905 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11491 689 685 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11492 688 686 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11493 VD 477 906 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11494 906 640 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11495 VD 533 906 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11496 906 685 686 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11497 1461 481 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11498 VD 676 903 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11499 VD 481 899 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11500 676 672 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11501 899 576 666 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11502 675 673 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11503 666 481 1460 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11504 VD 482 902 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11505 1460 646 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11506 902 670 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11507 VD 646 899 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11508 VD 505 902 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11509 902 672 673 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11510 673 505 1465 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11511 1465 670 1464 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11512 1464 482 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11513 VD 482 901 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11514 682 678 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11515 901 505 672 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11516 681 679 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11517 672 482 1463 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11518 VD 459 904 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11519 1463 670 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11520 904 676 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11521 VD 670 901 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11522 VD 610 904 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11523 670 666 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11524 904 678 679 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11525 669 667 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11526 679 610 1468 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11527 VD 481 900 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11528 1468 676 1467 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11529 900 646 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11530 1467 459 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11531 VD 576 900 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11532 VD 459 903 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11533 900 666 667 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11534 903 610 678 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11535 667 576 1462 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11536 678 459 1466 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11537 1462 646 1461 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11538 1466 676 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11539 896 709 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11540 VD 708 896 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M11541 709 561 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=1.70999999227206E-6
+PS=1.97999997908482E-6 M=1
M11542 708 682 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11543 712 711 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11544 VD 561 711 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11545 711 682 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11546 896 561 710 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=437.400007706479E-15 PD=1.7999999499807E-6
+PS=1.07999994725105E-6 M=1
M11547 710 682 896 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=218.700003853239E-15 PD=1.07999994725105E-6
+PS=539.999973625527E-9 M=1
M11548 VD 586 893 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11549 893 536 642 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11550 642 586 1457 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11551 1457 689 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11552 VD 689 893 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11553 640 636 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11554 639 637 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11555 VD 538 892 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11556 892 695 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11557 VD 582 892 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11558 892 636 637 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11559 637 582 1456 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11560 1456 695 1455 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11561 1455 538 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11562 VD 538 891 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11563 646 642 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11564 891 582 636 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11565 645 643 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11566 636 538 1454 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11567 VD 586 894 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11568 894 689 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11569 VD 536 894 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11570 894 642 643 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11571 643 536 1459 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11572 1459 689 1458 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11573 1458 586 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11574 612 590 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11575 602 590 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11576 601 612 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11577 600 612 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11578 VD CLK 591 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11579 586 585 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11580 585 584 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11581 584 600 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11582 VD 304 1439 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11583 1439 600 583 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11584 582 581 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11585 581 580 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11586 580 600 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11587 VD 299 1438 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11588 1438 600 579 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11589 578 601 1437 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11590 1437 368 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11591 VD 601 OLI_15 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11592 VD OLI_15 577 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11593 VD 577 576 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11594 545 CLK 1430 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11595 1430 570 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11596 VD CLK 544 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11597 VD 544 543 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11598 536 535 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11599 535 OLI_13 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11600 OLI_13 601 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11601 VD 311 1420 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11602 1420 601 534 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11603 533 532 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11604 532 531 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11605 531 600 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11606 VD 305 1419 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11607 1419 600 530 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11608 529 528 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11609 528 527 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11610 527 600 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11611 VD 293 1418 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11612 1418 600 526 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11613 VD 483 482 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11614 481 480 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11615 480 479 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11616 479 601 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11617 VD 310 1409 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11618 1409 601 478 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11619 477 476 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11620 476 475 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11621 475 601 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11622 VD 298 1408 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11623 1408 601 474 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11624 484 601 1410 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11625 1410 366 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11626 VD 601 OLI_16 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11627 VD OLI_16 483 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11628 402 602 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11629 1397 B_7 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11630 VD 393 433 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11631 VD 433 432 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11632 VD 432 431 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11633 430 393 1396 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11634 1396 B_6 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11635 VD 393 429 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11636 VD 429 428 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11637 VD 428 427 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11638 426 393 1395 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11639 1395 B_5 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11640 VD 393 425 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11641 VD 425 424 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11642 VD 424 423 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11643 422 393 1394 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11644 1394 B_4 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11645 VD 393 421 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11646 VD 421 420 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11647 VD 420 419 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11648 434 393 1397 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11649 VD 602 393 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11650 360 375 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11651 VD A_1 1384 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11652 1384 375 359 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11653 358 357 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11654 357 356 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11655 356 375 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11656 VD A_2 1383 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11657 1383 375 355 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11658 354 353 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11659 353 352 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11660 352 375 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11661 VD A_3 1382 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11662 1382 375 351 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11663 A0ININ 365 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11664 365 364 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11665 364 375 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11666 VD A_0 1385 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11667 1385 375 363 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11668 362 361 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11669 361 360 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11670 VD 602 375 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11671 VD 721 745 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11672 781 780 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11673 780 722 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11674 VD 633 1494 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11675 1494 722 779 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11676 S_6 778 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11677 778 777 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11678 777 722 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11679 VD 700 1493 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11680 1493 722 776 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11681 S_5 775 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11682 775 774 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11683 774 722 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11684 VD 659 1492 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11685 1492 722 773 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11686 VD 741 1491 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11687 1491 745 770 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11688 S_3 769 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11689 769 768 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11690 768 745 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11691 VD 737 1490 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11692 1490 745 767 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11693 S_2 766 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11694 766 765 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11695 765 745 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11696 VD 733 1489 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11697 1489 745 764 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11698 S_1 763 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11699 763 762 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11700 762 745 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11701 VD 729 1488 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11702 1488 745 761 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11703 S_0 760 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11704 760 759 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11705 759 745 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11706 VD 725 1487 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11707 S_4 772 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11708 1487 745 758 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11709 772 771 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11710 771 745 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11711 VD 726 725 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11712 1482 655 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11713 VD 719 743 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11714 VD 743 742 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11715 VD 742 741 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11716 740 719 1481 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11717 1481 664 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11718 VD 719 739 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11719 VD 739 738 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11720 VD 738 737 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11721 736 719 1480 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11722 1480 706 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11723 VD 719 735 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11724 VD 735 734 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11725 VD 734 733 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11726 732 719 1479 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11727 1479 705 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11728 VD 719 731 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11729 VD 731 730 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11730 VD 730 729 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11731 728 719 1478 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11732 1478 1 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11733 VD 719 727 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11734 VD 727 726 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11735 744 719 1482 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11736 697 588 1475 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11737 1475 661 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11738 VD 661 909 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11739 701 697 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11740 700 698 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11741 VD 588 910 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11742 910 661 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11743 VD 472 910 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11744 910 697 698 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11745 698 472 1477 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11746 1477 661 1476 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11747 1476 588 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11748 VD 588 909 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11749 909 472 697 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11750 694 692 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11751 VD 537 908 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11752 908 634 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11753 VD 529 908 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11754 908 691 692 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11755 692 529 1474 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11756 1474 634 1473 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11757 1473 537 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11758 VD 537 907 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11759 907 529 691 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11760 691 537 1472 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11761 1472 634 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11762 VD 634 907 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11763 VD 489 890 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=899.999974990351E-9 M=1
M11764 890 630 631 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=899.999974990351E-9
+PS=1.17000001864653E-6 M=1
M11765 631 489 1453 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=200.474999014627E-15 PD=1.17000001864653E-6
+PS=494.999994771206E-9 M=1
M11766 1453 701 1452 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=182.249994176015E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11767 1452 523 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11768 VD 523 889 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=218.700003853239E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11769 889 489 630 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=473.850017383703E-15 PD=539.999973625527E-9
+PS=1.17000001864653E-6 M=1
M11770 630 523 1451 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=182.249994176015E-15 PD=1.17000001864653E-6
+PS=449.999987495175E-9 M=1
M11771 1451 701 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=255.150013530464E-15 PD=449.999987495175E-9
+PS=629.999988177588E-9 M=1
M11772 VD 701 889 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=400.949998029254E-15 PD=629.999988177588E-9
+PS=1.7999999499807E-6 M=1
M11773 634 630 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=364.499988352029E-15 PD=2.34000003729307E-6
+PS=1.70999999227206E-6 M=1
M11774 633 631 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=619.650001882494E-15 AS=218.700003853239E-15 PD=2.34000003729307E-6
+PS=539.999973625527E-9 M=1
M11775 VD 523 890 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11776 890 701 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11777 VD 657 887 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=400.949998029254E-15 PD=539.999973625527E-9
+PS=1.7999999499807E-6 M=1
M11778 658 571 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=473.850017383703E-15 PD=1.70999999227206E-6
+PS=1.97999997908482E-6 M=1
M11779 657 618 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11780 661 660 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11781 VD 571 660 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11782 660 618 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11783 887 571 659 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=437.400007706479E-15 PD=1.7999999499807E-6
+PS=1.07999994725105E-6 M=1
M11784 659 618 887 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=218.700003853239E-15 PD=1.07999994725105E-6
+PS=539.999973625527E-9 M=1
M11785 887 658 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11786 VD 593 606 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11787 593 CLK_EN VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11788 VD 593 555 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11789 VD 524 566 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11790 566 542 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11791 VD 555 451 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11792 387 451 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11793 VD 416 415 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11794 414 387 1392 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11795 1392 B_2 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11796 VD 387 413 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11797 VD 413 412 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11798 VD 412 411 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11799 410 387 1391 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11800 1391 B_1 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11801 VD 387 409 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11802 VD 409 408 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11803 VD 408 407 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11804 406 387 1390 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=583.199992205269E-15 AS=182.249994176015E-15 PD=2.25000007958442E-6
+PS=449.999987495175E-9 M=1
M11805 1390 B_0 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=218.700003853239E-15 PD=449.999987495175E-9
+PS=539.999973625527E-9 M=1
M11806 VD 387 405 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11807 VD 405 404 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11808 VD 404 403 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=510.300027060928E-15 AS=364.499988352029E-15 PD=2.06999993679347E-6
+PS=1.70999999227206E-6 M=1
M11809 VD 417 416 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11810 VD 451 388 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11811 342 341 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11812 341 340 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11813 340 369 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11814 VD A_6 1379 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11815 1379 369 339 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11816 338 337 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11817 337 336 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11818 336 369 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11819 VD A_7 1378 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11820 1378 369 335 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11821 348 369 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11822 VD A_4 1381 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11823 1381 369 347 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11824 346 345 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M11825 345 344 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11826 344 369 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11827 VD A_5 1380 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M11828 1380 369 343 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M11829 369 451 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11830 1370 235 334 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=473.850017383703E-15 PD=449.999987495175E-9
+PS=1.17000001864653E-6 M=1
M11831 334 282 848 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=218.700003853239E-15 PD=1.17000001864653E-6
+PS=539.999973625527E-9 M=1
M11832 848 235 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=255.150013530464E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M11833 VD 235 1369 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11834 1369 245 1368 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=200.474999014627E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11835 1368 282 332 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=200.474999014627E-15 AS=473.850017383703E-15 PD=494.999994771206E-9
+PS=1.17000001864653E-6 M=1
M11836 332 334 847 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.17000001864653E-6
+PS=899.999974990351E-9 M=1
M11837 847 282 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=899.999974990351E-9
+PS=539.999973625527E-9 M=1
M11838 VD 245 847 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11839 847 235 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11840 VD 332 330 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=619.650001882494E-15 PD=539.999973625527E-9
+PS=2.34000003729307E-6 M=1
M11841 VD 334 329 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=619.650001882494E-15 PD=1.70999999227206E-6
+PS=2.34000003729307E-6 M=1
M11842 848 245 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=255.150013530464E-15 PD=1.7999999499807E-6
+PS=629.999988177588E-9 M=1
M11843 VD 245 1370 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=255.150013530464E-15 AS=182.249994176015E-15 PD=629.999988177588E-9
+PS=449.999987495175E-9 M=1
M11844 VD 244 328 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11845 VD 101 327 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=473.850017383703E-15 AS=364.499988352029E-15 PD=1.97999997908482E-6
+PS=1.70999999227206E-6 M=1
M11846 846 328 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=400.949998029254E-15 AS=218.700003853239E-15 PD=1.7999999499807E-6
+PS=539.999973625527E-9 M=1
M11847 VD 327 846 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=218.700003853239E-15 PD=539.999973625527E-9
+PS=539.999973625527E-9 M=1
M11848 846 244 326 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=437.400007706479E-15 PD=539.999973625527E-9
+PS=1.07999994725105E-6 M=1
M11849 326 101 846 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=437.400007706479E-15 AS=400.949998029254E-15 PD=1.07999994725105E-6
+PS=1.7999999499807E-6 M=1
M11850 VD 244 325 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M11851 325 101 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=364.499988352029E-15 PD=539.999973625527E-9
+PS=1.70999999227206E-6 M=1
M11852 VD 325 324 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M11853 1033 142 288 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M11854 289 322 281 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M11855 288 280 1032 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M11856 281 227 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M11857 1032 246 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M11858 GD 105 281 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M11859 281 171 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M11860 280 164 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11861 279 200 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M11862 278 199 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M11863 GD 289 247 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M11864 246 142 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11865 245 234 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M11866 244 233 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M11867 GD 322 243 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M11868 GD 38 242 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M11869 GD 166 241 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M11870 242 7 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M11871 241 144 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M11872 GD 113 242 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M11873 GD 134 241 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M11874 242 200 234 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M11875 241 199 233 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M11876 201 A7B3 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M11877 GD A7B3 993 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M11878 993 A6B4 202 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M11879 202 138 201 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M11880 201 A6B4 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M11881 GD A6B4 990 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M11882 990 A7B3 987 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M11883 987 138 197 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M11884 197 202 172 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M11885 172 138 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M11886 GD A7B3 172 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M11887 172 A6B4 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M11888 GD 197 171 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M11889 GD 202 170 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M11890 A6B4 162 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11891 169 161 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11892 168 160 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11893 167 159 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11894 166 158 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11895 165 157 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11896 164 156 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11897 A7B4 163 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11898 159 419 970 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11899 158 419 969 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11900 157 419 968 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11901 156 419 967 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11902 163 419 974 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11903 162 419 973 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11904 161 419 972 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11905 160 419 971 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11906 967 A0ININ GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11907 974 338 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11908 973 342 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11909 972 346 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11910 971 350 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11911 970 354 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11912 969 358 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11913 968 362 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11914 140 132 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11915 139 131 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11916 138 130 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11917 137 129 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11918 136 128 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11919 135 127 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11920 134 126 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11921 133 125 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11922 132 423 958 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11923 131 423 957 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11924 130 423 956 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11925 129 423 955 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11926 128 423 954 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11927 127 423 953 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11928 126 423 952 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11929 125 423 951 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11930 955 350 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11931 954 354 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11932 953 358 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11933 952 362 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11934 951 A0ININ GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11935 958 338 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11936 957 342 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11937 956 346 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11938 104 96 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11939 103 95 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11940 102 94 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11941 101 93 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11942 108 100 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11943 107 99 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11944 106 98 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11945 105 97 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11946 93 427 935 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11947 100 427 942 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11948 99 427 941 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11949 98 427 940 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11950 97 427 939 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11951 96 427 938 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11952 95 427 937 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11953 94 427 936 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11954 942 338 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11955 941 342 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11956 940 346 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11957 939 350 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11958 938 354 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11959 937 358 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11960 936 362 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11961 935 A0ININ GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11962 32 24 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11963 31 23 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11964 30 22 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11965 29 21 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11966 28 20 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11967 27 19 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11968 26 18 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11969 25 17 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M11970 21 431 923 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11971 20 431 922 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11972 19 431 921 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11973 18 431 920 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11974 17 431 919 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11975 24 431 926 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11976 23 431 925 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11977 22 431 924 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M11978 920 362 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11979 919 A0ININ GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11980 926 338 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11981 925 342 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11982 924 346 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11983 923 350 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11984 922 354 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11985 921 358 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M11986 234 113 1010 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M11987 233 134 1009 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M11988 1010 7 992 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11989 1009 144 991 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M11990 992 38 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M11991 991 166 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M11992 GD 38 198 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M11993 GD 166 196 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M11994 198 113 200 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M11995 196 134 199 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M11996 200 38 989 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M11997 199 166 988 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M11998 989 7 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M11999 988 144 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12000 GD 7 198 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12001 GD 144 196 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12002 GD 338 966 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12003 GD 342 965 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12004 GD 346 964 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12005 GD 350 963 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12006 GD 354 962 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12007 GD 358 961 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12008 GD 362 960 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12009 GD A0ININ 959 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12010 964 415 153 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12011 963 415 152 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12012 962 415 151 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12013 961 415 150 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12014 960 415 149 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12015 959 415 148 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12016 966 415 155 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12017 965 415 154 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12018 GD 150 143 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12019 GD 149 142 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12020 GD 148 141 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12021 GD 155 A7B3 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12022 GD 154 147 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12023 GD 153 146 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12024 GD 152 145 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12025 GD 151 144 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12026 GD 362 944 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12027 GD A0ININ 943 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12028 GD 338 950 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12029 GD 342 949 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12030 GD 346 948 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12031 GD 350 947 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12032 GD 354 946 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12033 GD 358 945 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12034 950 411 124 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12035 949 411 123 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12036 948 411 122 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12037 947 411 121 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12038 946 411 120 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12039 945 411 119 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12040 944 411 118 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12041 943 411 117 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12042 GD 123 115 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12043 GD 122 114 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12044 GD 121 113 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12045 GD 120 112 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12046 GD 119 111 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12047 GD 118 110 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12048 GD 117 109 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12049 GD 124 116 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12050 GD 346 932 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12051 GD 350 931 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12052 GD 354 930 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12053 GD 358 929 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12054 GD 362 928 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12055 GD A0ININ 927 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12056 GD 338 934 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12057 GD 342 933 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12058 929 407 43 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12059 928 407 42 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12060 927 407 41 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12061 934 407 92 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12062 933 407 91 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12063 932 407 90 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12064 931 407 89 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12065 930 407 44 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12066 GD 92 40 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12067 GD 91 39 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12068 GD 90 38 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12069 GD 89 37 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12070 GD 44 36 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12071 GD 43 35 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12072 GD 42 34 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12073 GD 41 33 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12074 GD 338 918 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12075 GD 342 917 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12076 GD 346 916 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12077 GD 350 915 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12078 GD 354 914 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12079 GD 358 913 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12080 GD 362 912 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12081 GD A0ININ 911 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M12082 917 403 15 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12083 916 403 14 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12084 915 403 13 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12085 914 403 12 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12086 913 403 11 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12087 912 403 10 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12088 911 403 9 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12089 918 403 16 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M12090 GD 12 4 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12091 GD 11 3 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12092 GD 10 2 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12093 GD 9 1 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12094 GD 16 8 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12095 GD 15 7 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12096 GD 14 6 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12097 GD 13 5 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12098 724 721 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12099 723 721 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12100 GD A7B4 650 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12101 628 605 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12102 GD 139 626 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12103 GD 402 1209 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12104 1209 628 625 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12105 GD 650 1208 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=72.8999990256586E-15 PD=1.4400000054593E-6
+PS=539.999973625527E-9 M=1
M12106 1208 626 621 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=89.0999988091383E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M12107 GD 32 620 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12108 GD 625 1205 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M12109 621 A7B4 1206 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12110 1206 139 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12111 1205 402 615 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M12112 GD 521 614 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12113 GD A7B4 1201 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12114 GD 615 610 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12115 1201 139 608 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12116 GD 620 1196 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=72.8999990256586E-15 PD=1.4400000054593E-6
+PS=539.999973625527E-9 M=1
M12117 1196 614 605 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=89.0999988091383E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M12118 605 32 1193 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12119 604 564 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12120 1193 521 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12121 GD 608 596 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=153.900004719321E-15 PD=1.62000003456342E-6
+PS=1.35000004775065E-6 M=1
M12122 GD 402 1190 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12123 GD 108 595 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12124 1190 604 592 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12125 GD 32 1187 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12126 1187 521 575 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12127 GD 31 574 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12128 GD 592 1179 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M12129 1179 402 567 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M12130 GD 595 1175 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=72.8999990256586E-15 PD=1.4400000054593E-6
+PS=539.999973625527E-9 M=1
M12131 551 140 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12132 GD 575 564 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=153.900004719321E-15 PD=1.62000003456342E-6
+PS=1.35000004775065E-6 M=1
M12133 1175 574 563 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=89.0999988091383E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M12134 GD 567 561 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12135 GD 140 1173 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12136 563 108 1172 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12137 1173 107 554 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12138 1172 31 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12139 553 460 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12140 554 596 551 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12141 GD 108 1169 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12142 GD 402 1167 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12143 1169 31 546 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12144 551 107 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12145 1167 553 541 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12146 512 563 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12147 GD 107 1164 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12148 GD 563 1163 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12149 1164 140 1156 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12150 1163 485 522 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12151 1156 596 520 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12152 GD 541 1155 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M12153 GD 546 521 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=153.900004719321E-15 PD=1.62000003456342E-6
+PS=1.35000004775065E-6 M=1
M12154 1155 402 514 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M12155 522 436 512 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12156 520 554 502 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12157 512 485 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12158 GD 514 505 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12159 502 596 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12160 GD 485 1148 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12161 GD 140 502 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12162 1148 563 1144 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12163 502 107 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12164 1144 436 497 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12165 GD 494 499 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12166 501 454 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12167 GD 520 494 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12168 GD 402 1135 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12169 497 522 473 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12170 1135 501 493 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12171 GD 377 492 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12172 GD 554 485 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12173 473 436 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12174 GD 499 1125 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=72.8999990256586E-15 PD=1.4400000054593E-6
+PS=539.999973625527E-9 M=1
M12175 GD 563 473 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12176 GD 493 1124 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M12177 GD 536 1123 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12178 1125 492 470 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=89.0999988091383E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M12179 473 485 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12180 1124 402 468 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M12181 1123 586 467 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12182 470 494 1119 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12183 GD 497 460 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12184 467 457 1118 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M12185 1119 377 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12186 GD 468 459 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12187 1118 445 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M12188 GD 522 454 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12189 441 621 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12190 GD 494 1114 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12191 1114 377 453 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12192 457 536 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12193 GD 621 1112 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12194 1112 106 442 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12195 445 586 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12196 442 170 441 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12197 GD 453 436 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=153.900004719321E-15 PD=1.62000003456342E-6
+PS=1.35000004775065E-6 M=1
M12198 441 106 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12199 395 470 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12200 GD 106 1094 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12201 GD 470 1093 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12202 1094 621 1092 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12203 1093 367 401 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12204 1092 170 400 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12205 401 30 395 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12206 GD 383 394 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12207 400 442 385 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12208 395 367 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12209 385 170 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12210 GD 367 1091 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12211 GD 243 386 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12212 GD 621 385 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12213 1091 470 1086 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12214 385 106 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12215 1086 30 384 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12216 GD 394 1081 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=72.8999990256586E-15 PD=1.4400000054593E-6
+PS=539.999973625527E-9 M=1
M12217 GD 400 383 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12218 1081 386 382 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=89.0999988091383E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M12219 384 401 376 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12220 382 383 1080 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12221 1080 243 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12222 GD 442 377 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12223 376 30 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12224 GD 470 376 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12225 GD 383 1075 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12226 376 367 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12227 1075 243 374 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12228 GD 384 368 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12229 GD 401 366 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12230 291 105 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12231 GD 374 367 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=153.900004719321E-15 PD=1.62000003456342E-6
+PS=1.35000004775065E-6 M=1
M12232 GD 105 1052 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12233 1052 171 322 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12234 322 227 291 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12235 291 171 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12236 GD 171 1035 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12237 1035 105 1034 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12238 1034 227 289 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12239 618 613 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12240 617 652 1204 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12241 616 109 1203 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12242 GD 653 1202 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12243 CLK_EN 607 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12244 1204 548 1200 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12245 1203 3 1199 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12246 613 388 1198 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12247 1202 549 609 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12248 1200 141 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12249 1199 34 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12250 611 627 1197 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12251 1198 603 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12252 609 597 1195 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M12253 1197 550 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12254 GD 141 573 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12255 GD 34 572 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12256 607 570 1194 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M12257 1195 587 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M12258 573 652 599 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M12259 572 109 598 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M12260 1194 CLK GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M12261 603 589 1192 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12262 GD 627 1191 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12263 1192 388 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12264 597 653 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12265 1191 550 594 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12266 599 141 1189 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M12267 598 34 1188 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M12268 GD 704 589 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12269 594 568 1186 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M12270 1189 548 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12271 1188 3 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12272 588 569 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12273 1186 562 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M12274 587 549 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12275 GD 548 573 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12276 GD 3 572 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12277 571 565 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12278 568 627 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12279 570 591 1178 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12280 569 606 1177 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12281 1178 560 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12282 1177 559 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12283 565 388 1174 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12284 562 550 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12285 1174 552 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12286 552 539 1168 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12287 1168 388 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12288 GD 594 539 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12289 523 509 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12290 509 388 1151 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12291 1151 500 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12292 500 491 1137 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12293 1137 388 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12294 GD 540 491 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12295 472 461 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12296 461 388 1115 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12297 1115 452 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12298 452 440 1111 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12299 1111 388 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12300 GD 498 440 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12301 560 591 1171 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12302 559 547 1170 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12303 1170 606 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12304 1171 566 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12305 GD 619 547 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12306 538 519 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12307 537 518 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12308 525 511 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12309 524 510 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12310 519 555 1154 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12311 518 606 1153 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12312 1154 504 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12313 1153 503 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12314 511 467 1150 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M12315 510 525 1149 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=251.100003420199E-15 AS=72.8999990256586E-15 PD=2.06999993679347E-6
+PS=539.999973625527E-9 M=1
M12316 1150 466 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M12317 1149 465 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=226.799996968716E-15 PD=539.999973625527E-9
+PS=1.89000002137618E-6 M=1
M12318 504 496 1143 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12319 503 495 1142 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12320 1143 555 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12321 1142 606 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12322 GD 292 496 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12323 GD 447 495 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12324 489 471 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12325 GD 533 1122 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12326 GD 582 1121 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12327 1122 477 466 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12328 1121 538 465 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12329 471 606 1120 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12330 466 456 1117 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M12331 465 455 1116 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M12332 1120 458 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12333 1117 444 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M12334 1116 443 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M12335 458 446 1113 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12336 456 533 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12337 455 582 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12338 1113 606 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12339 GD 435 446 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12340 444 477 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12341 443 538 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12342 558 490 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12343 557 488 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12344 556 487 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12345 550 508 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M12346 549 507 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M12347 548 506 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M12348 GD 283 517 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12349 GD 288 516 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12350 GD 35 515 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12351 540 513 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=190.350000844018E-15 PD=1.35000004775065E-6
+PS=1.62000003456342E-6 M=1
M12352 517 437 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12353 516 439 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12354 515 4 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12355 GD 557 517 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M12356 GD 556 516 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M12357 GD 110 515 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M12358 517 490 508 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12359 513 558 1152 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12360 516 488 507 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12361 515 487 506 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12362 1152 438 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12363 508 557 1147 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12364 507 556 1146 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12365 506 110 1145 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12366 1147 437 1140 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12367 GD 558 1141 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12368 1146 439 1139 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12369 1145 4 1138 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12370 1141 438 498 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12371 1140 283 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12372 1139 288 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12373 1138 35 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12374 498 486 1136 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M12375 GD 283 464 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12376 GD 288 463 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12377 GD 35 462 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12378 1136 469 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M12379 464 557 490 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M12380 463 556 488 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M12381 462 110 487 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M12382 486 558 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12383 490 283 1128 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M12384 488 288 1127 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M12385 487 35 1126 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M12386 1128 437 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12387 1127 439 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12388 1126 4 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12389 GD 437 464 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12390 469 438 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12391 GD 439 463 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12392 GD 4 462 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12393 450 381 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12394 449 380 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12395 448 379 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12396 447 378 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12397 439 392 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M12398 438 391 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M12399 437 390 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M12400 435 389 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M12401 GD 36 399 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12402 GD 330 398 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12403 GD 323 397 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12404 GD 204 396 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12405 399 5 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12406 398 326 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12407 397 236 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12408 396 249 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12409 GD 111 399 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M12410 GD 448 398 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M12411 GD 450 397 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M12412 GD 449 396 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M12413 399 381 392 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12414 398 380 391 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12415 397 379 390 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12416 396 378 389 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12417 392 111 1090 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12418 391 448 1089 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12419 390 450 1088 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12420 389 449 1087 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12421 1090 5 1085 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12422 1089 326 1084 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12423 1088 236 1083 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12424 1087 249 1082 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12425 1085 36 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12426 1084 330 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12427 1083 323 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12428 1082 204 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12429 GD 36 373 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12430 GD 330 372 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12431 GD 323 371 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12432 GD 204 370 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12433 373 111 381 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M12434 372 448 380 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M12435 371 450 379 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M12436 370 449 378 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M12437 381 36 1079 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M12438 380 330 1078 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M12439 379 323 1077 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M12440 378 204 1076 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M12441 1079 5 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12442 1078 326 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12443 1077 236 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12444 1076 249 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12445 GD 5 373 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12446 GD 326 372 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12447 GD 236 371 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12448 GD 249 370 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12449 323 290 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=190.350000844018E-15 PD=1.35000004775065E-6
+PS=1.62000003456342E-6 M=1
M12450 290 164 1036 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12451 1036 142 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12452 GD 164 1033 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12453 722 721 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12454 721 720 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12455 720 593 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12456 719 716 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12457 718 715 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=190.350000844018E-15 PD=1.35000004775065E-6
+PS=1.62000003456342E-6 M=1
M12458 717 714 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=190.350000844018E-15 PD=1.35000004775065E-6
+PS=1.62000003456342E-6 M=1
M12459 716 606 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12460 715 717 1254 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12461 714 33 1253 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12462 713 707 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=190.350000844018E-15 PD=1.35000004775065E-6
+PS=1.62000003456342E-6 M=1
M12463 1254 648 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12464 1253 2 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12465 GD 717 1249 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12466 GD 33 1248 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12467 1249 648 706 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12468 1248 2 705 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12469 707 718 1247 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12470 706 703 1246 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M12471 705 702 1245 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M12472 1247 649 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12473 704 683 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=190.350000844018E-15 PD=1.35000004775065E-6
+PS=1.62000003456342E-6 M=1
M12474 1246 663 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M12475 1245 662 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M12476 GD 718 1244 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12477 1244 649 664 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12478 703 717 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12479 702 33 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12480 683 713 1225 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12481 664 656 1224 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M12482 1225 609 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12483 1224 654 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M12484 663 648 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12485 662 2 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12486 GD 713 1220 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12487 656 718 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12488 1220 609 655 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12489 655 651 1219 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M12490 1219 647 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M12491 654 649 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12492 653 599 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12493 652 598 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12494 651 713 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12495 647 609 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12496 649 617 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M12497 648 616 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M12498 GD 141 624 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12499 GD 34 623 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12500 627 622 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=190.350000844018E-15 PD=1.35000004775065E-6
+PS=1.62000003456342E-6 M=1
M12501 624 548 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12502 623 3 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12503 GD 652 624 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M12504 GD 109 623 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M12505 622 653 1207 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12506 624 599 617 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12507 623 598 616 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12508 1207 549 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12509 619 611 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=190.350000844018E-15 PD=1.35000004775065E-6
+PS=1.62000003456342E-6 M=1
M12510 S_7 781 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12511 781 722 1288 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12512 695 691 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12513 1213 695 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12514 GD 695 635 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12515 GD 593 590 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12516 1165 CLK 543 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M12517 GD 543 542 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12518 418 B_3 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12519 GD 387 1102 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12520 1102 418 417 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12521 350 349 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12522 349 369 1066 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12523 1066 348 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12524 303 254 302 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12525 302 261 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12526 GD 261 1041 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12527 1041 317 1040 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12528 287 133 286 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12529 286 165 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12530 GD 165 1030 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12531 1030 143 1029 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12532 1029 133 285 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12533 285 287 284 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12534 284 133 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12535 GD 143 284 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12536 284 165 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12537 GD 285 283 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12538 GD 287 282 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12539 286 143 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12540 GD 143 1031 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12541 1031 165 287 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12542 GD 216 256 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12543 GD 273 1022 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12544 1027 228 1026 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12545 256 203 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12546 1022 221 265 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12547 1026 185 275 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12548 GD 257 255 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12549 265 215 264 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12550 275 277 274 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12551 GD 259 254 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12552 264 221 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12553 274 185 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12554 252 210 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12555 GD 221 1021 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12556 GD 228 274 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12557 GD 210 1016 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12558 1021 273 1020 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12559 274 190 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12560 1016 329 253 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12561 1020 215 263 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12562 GD 275 273 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12563 253 324 252 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12564 263 265 262 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12565 GD 277 272 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12566 252 329 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12567 262 215 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12568 270 316 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12569 GD 329 1015 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12570 GD 273 262 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12571 GD 316 1025 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12572 1015 210 1014 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12573 262 221 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12574 1025 247 271 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12575 1014 324 251 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12576 GD 263 261 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12577 271 272 270 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12578 251 253 250 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12579 GD 265 260 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12580 270 247 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12581 250 324 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12582 258 216 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12583 GD 247 1024 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12584 GD 210 250 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12585 GD 216 1019 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12586 1024 316 1023 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12587 250 329 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12588 1019 203 259 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12589 1023 272 269 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12590 GD 251 249 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12591 259 209 258 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12592 269 271 268 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12593 GD 253 248 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12594 258 203 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12595 268 272 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12596 276 228 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12597 GD 203 1018 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12598 GD 316 268 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12599 GD 228 1028 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12600 1018 216 1017 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12601 268 247 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12602 1028 190 277 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12603 1017 209 257 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12604 GD 269 267 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12605 277 185 276 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12606 257 259 256 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12607 GD 271 266 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12608 276 190 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12609 256 209 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12610 264 273 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12611 GD 190 1027 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12612 239 6 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12613 GD 6 1013 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12614 1013 37 240 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12615 240 112 239 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12616 239 37 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12617 GD 37 1012 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12618 1012 6 1011 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12619 1011 112 238 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12620 238 240 237 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12621 237 112 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12622 GD 6 237 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12623 237 37 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12624 GD 238 236 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12625 GD 240 235 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12626 208 174 207 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12627 207 102 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12628 GD 102 995 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12629 995 25 994 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12630 976 145 975 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12631 178 135 177 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12632 177 167 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12633 GD 167 976 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12634 GD 220 215 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12635 225 26 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12636 GD 26 1004 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12637 1004 103 1003 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12638 1003 187 224 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12639 224 226 223 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12640 223 187 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12641 231 147 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12642 GD 103 223 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12643 GD 147 1008 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12644 223 26 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12645 1008 169 232 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12646 GD 224 222 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12647 232 137 231 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12648 GD 226 221 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12649 231 169 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12650 219 191 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12651 GD 169 1007 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12652 GD 191 1002 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12653 1007 147 1006 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12654 1002 179 220 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12655 1006 137 230 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12656 220 173 219 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12657 230 232 229 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12658 219 179 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12659 229 137 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12660 GD 179 1001 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12661 GD 147 229 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12662 1001 191 1000 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12663 229 169 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12664 1000 173 218 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12665 GD 230 228 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12666 218 220 217 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12667 GD 232 227 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12668 217 173 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12669 225 103 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12670 GD 191 217 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12671 GD 103 1005 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12672 217 179 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12673 1005 26 226 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12674 GD 218 216 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12675 226 187 225 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12676 207 25 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12677 GD 25 996 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12678 996 102 208 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12679 GD 40 981 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12680 981 115 186 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12681 GD 186 185 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=153.900004719321E-15 PD=1.62000003456342E-6
+PS=1.35000004775065E-6 M=1
M12682 194 146 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12683 GD 146 986 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12684 986 168 195 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12685 195 136 194 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12686 194 168 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12687 GD 168 985 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12688 985 146 984 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12689 984 136 193 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12690 193 195 192 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12691 192 136 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12692 GD 146 192 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12693 192 168 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12694 GD 193 191 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12695 GD 195 190 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12696 GD 40 189 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12697 GD 115 188 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12698 GD 189 983 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=72.8999990256586E-15 PD=1.4400000054593E-6
+PS=539.999973625527E-9 M=1
M12699 983 188 187 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=89.0999988091383E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M12700 187 40 982 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12701 982 115 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12702 177 145 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12703 GD 145 977 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12704 977 167 178 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12705 213 180 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12706 GD 180 999 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12707 999 278 214 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12708 214 279 213 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12709 213 278 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12710 GD 278 998 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12711 998 180 997 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12712 997 279 212 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12713 212 214 211 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12714 211 279 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12715 GD 180 211 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12716 211 278 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12717 GD 212 210 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12718 GD 214 209 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12719 206 208 205 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12720 205 174 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12721 GD 25 205 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12722 205 102 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12723 GD 206 204 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12724 GD 208 203 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12725 994 174 206 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12726 183 8 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12727 GD 8 980 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12728 980 39 184 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12729 184 114 183 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12730 183 39 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12731 GD 39 979 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12732 979 8 978 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12733 978 114 182 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12734 182 184 181 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12735 181 114 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12736 GD 8 181 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12737 181 39 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12738 GD 182 180 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12739 GD 184 179 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12740 975 135 176 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12741 176 178 175 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12742 175 135 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12743 GD 145 175 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12744 175 167 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12745 GD 176 174 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12746 GD 178 173 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12747 1298 795 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12748 795 794 1297 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12749 1297 723 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12750 GD 669 794 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12751 673 505 1231 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12752 1231 670 1230 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12753 1230 482 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12754 GD 482 671 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12755 671 505 672 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M12756 612 590 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12757 602 590 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12758 601 612 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12759 600 612 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12760 GD CLK 591 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12761 GD 321 316 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12762 320 104 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12763 GD 104 1051 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12764 1051 27 321 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12765 321 116 320 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12766 320 27 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12767 GD 27 1050 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12768 1050 104 1049 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12769 1049 116 319 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12770 319 321 318 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12771 318 116 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12772 GD 104 318 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12773 318 27 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12774 GD 319 317 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12775 GD 304 583 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12776 582 581 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12777 581 600 1183 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12778 1183 580 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12779 580 579 1182 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12780 1182 600 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12781 GD 299 579 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12782 586 585 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12783 585 600 1185 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12784 1185 584 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12785 584 583 1184 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12786 1184 600 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12787 578 368 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12788 GD 601 1181 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12789 1181 578 OLI_15 GD  TSMC18DN  L=180.000000682412E-9
+W=269.999986812763E-9 AD=48.5999993504391E-15 AS=153.900004719321E-15
+PD=360.000001364824E-9 PS=1.35000004775065E-6 M=1
M12790 GD OLI_15 1180 GD  TSMC18DN  L=180.000000682412E-9
+W=269.999986812763E-9 AD=214.649993742974E-15 AS=60.7500025761806E-15
+PD=1.7999999499807E-6 PS=449.999987495175E-9 M=1
M12791 1180 601 577 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M12792 GD 577 576 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12793 545 570 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12794 GD CLK 1166 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12795 1166 545 544 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12796 GD 544 1165 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M12797 1158 527 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12798 527 526 1157 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12799 1157 600 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12800 GD 293 526 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12801 536 535 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12802 535 601 1162 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12803 1162 OLI_13 GD GD  TSMC18DN  L=180.000000682412E-9
+W=269.999986812763E-9 AD=60.7500025761806E-15 AS=214.649993742974E-15
+PD=449.999987495175E-9 PS=1.7999999499807E-6 M=1
M12804 OLI_13 534 1161 GD  TSMC18DN  L=180.000000682412E-9
+W=269.999986812763E-9 AD=153.900004719321E-15 AS=48.5999993504391E-15
+PD=1.35000004775065E-6 PS=360.000001364824E-9 M=1
M12805 1161 601 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12806 GD 311 534 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12807 533 532 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12808 532 600 1160 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12809 1160 531 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12810 531 530 1159 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12811 1159 600 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12812 GD 305 530 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12813 529 528 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12814 528 600 1158 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12815 1132 479 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12816 479 478 1131 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12817 1131 601 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12818 GD 310 478 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12819 477 476 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12820 476 601 1130 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12821 1130 475 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12822 475 474 1129 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12823 1129 601 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12824 GD 298 474 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12825 484 366 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12826 GD 601 1134 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12827 1134 484 OLI_16 GD  TSMC18DN  L=180.000000682412E-9
+W=269.999986812763E-9 AD=48.5999993504391E-15 AS=153.900004719321E-15
+PD=360.000001364824E-9 PS=1.35000004775065E-6 M=1
M12828 GD OLI_16 1133 GD  TSMC18DN  L=180.000000682412E-9
+W=269.999986812763E-9 AD=214.649993742974E-15 AS=60.7500025761806E-15
+PD=1.7999999499807E-6 PS=449.999987495175E-9 M=1
M12829 1133 601 483 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M12830 GD 483 482 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12831 481 480 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12832 480 601 1132 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12833 1105 393 424 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M12834 GD 424 423 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12835 422 B_4 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12836 GD 393 1104 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12837 1104 422 421 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12838 GD 421 1103 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M12839 1103 393 420 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M12840 GD 420 419 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12841 434 B_7 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12842 GD 393 1110 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12843 1110 434 433 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12844 GD 433 1109 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M12845 1109 393 432 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M12846 GD 432 431 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12847 430 B_6 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12848 GD 393 1108 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12849 1108 430 429 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12850 GD 429 1107 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M12851 1107 393 428 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M12852 GD 428 427 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12853 426 B_5 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M12854 GD 393 1106 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M12855 1106 426 425 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12856 GD 425 1105 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M12857 402 602 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12858 GD 602 393 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12859 GD 602 375 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12860 352 351 1067 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12861 1067 375 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12862 GD A_3 351 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12863 A0ININ 365 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12864 365 375 1074 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12865 1074 364 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12866 364 363 1073 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12867 1073 375 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12868 GD A_0 363 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12869 362 361 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12870 361 375 1072 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12871 1072 360 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12872 360 359 1071 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12873 1071 375 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12874 GD A_1 359 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12875 358 357 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12876 357 375 1070 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12877 1070 356 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12878 356 355 1069 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12879 1069 375 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12880 GD A_2 355 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12881 354 353 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12882 353 375 1068 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12883 1068 352 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12884 GD 267 306 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12885 GD 29 1048 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12886 306 28 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12887 1048 382 315 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12888 GD 307 305 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12889 315 266 314 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12890 GD 309 304 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12891 314 382 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12892 302 317 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12893 GD 382 1047 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12894 GD 317 1042 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12895 1047 29 1046 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12896 1042 261 303 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12897 1046 266 313 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12898 313 315 312 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12899 312 266 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12900 GD 29 312 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12901 312 382 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12902 GD 313 311 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M12903 GD 315 310 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M12904 308 267 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12905 GD 267 1045 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12906 1045 28 309 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M12907 309 260 308 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M12908 308 28 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M12909 GD 28 1044 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M12910 1044 267 1043 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M12911 1043 260 307 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M12912 307 309 306 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M12913 306 260 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M12914 314 29 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M12915 S_12 796 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12916 796 723 1298 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12917 GD 710 752 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12918 S_14 751 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12919 751 724 1268 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12920 1268 750 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12921 750 749 1267 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12922 1267 724 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12923 GD 681 749 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12924 S_13 748 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12925 748 724 1266 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12926 1266 747 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12927 747 746 1265 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12928 1265 724 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12929 GD 675 746 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12930 S_16 757 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12931 757 724 1272 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12932 1272 756 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12933 756 755 1271 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12934 1271 724 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12935 GD 712 755 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12936 S_15 754 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12937 754 724 1270 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12938 1270 753 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12939 753 752 1269 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12940 1269 724 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12941 712 711 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=190.350000844018E-15 PD=1.35000004775065E-6
+PS=1.62000003456342E-6 M=1
M12942 711 561 1252 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12943 1252 682 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M12944 GD 561 1251 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12945 1251 682 710 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12946 710 709 1250 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M12947 1250 708 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M12948 709 561 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12949 708 682 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12950 676 672 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12951 675 673 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M12952 GD 482 674 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12953 674 670 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12954 GD 505 674 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M12955 674 672 673 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12956 682 678 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M12957 681 679 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M12958 GD 459 680 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12959 680 676 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M12960 GD 610 680 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M12961 680 678 679 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12962 679 610 1234 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12963 1234 676 1233 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12964 1233 459 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12965 GD 459 677 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12966 677 610 678 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M12967 678 459 1232 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M12968 1232 676 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12969 GD 676 677 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M12970 1292 786 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12971 786 785 1291 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12972 1291 723 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12973 GD 639 785 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12974 S_11 793 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12975 793 723 1296 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12976 1296 792 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12977 792 791 1295 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12978 1295 723 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12979 GD 645 791 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12980 S_10 790 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12981 790 723 1294 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12982 1294 789 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12983 789 788 1293 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12984 1293 723 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12985 GD 688 788 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12986 S_9 787 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12987 787 723 1292 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12988 S_8 784 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M12989 784 722 1290 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M12990 1290 783 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M12991 783 782 1289 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M12992 1289 722 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M12993 GD 694 782 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M12994 687 685 686 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M12995 686 533 1237 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M12996 1237 640 1236 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M12997 1236 477 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M12998 GD 477 684 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M12999 684 533 685 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M13000 685 477 1235 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M13001 1235 640 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13002 GD 640 684 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M13003 689 685 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M13004 688 686 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M13005 GD 477 687 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13006 687 640 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13007 GD 533 687 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M13008 GD 481 665 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M13009 665 576 666 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M13010 666 481 1226 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M13011 1226 646 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13012 GD 646 665 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M13013 672 482 1229 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M13014 1229 670 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13015 GD 670 671 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M13016 670 666 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M13017 669 667 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M13018 GD 481 668 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13019 668 646 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13020 GD 576 668 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M13021 668 666 667 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M13022 667 576 1228 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M13023 1228 646 1227 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M13024 1227 481 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13025 GD 538 638 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13026 638 695 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13027 GD 582 638 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M13028 638 636 637 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M13029 637 582 1215 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M13030 1215 695 1214 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M13031 1214 538 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13032 GD 538 635 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M13033 646 642 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M13034 635 582 636 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M13035 645 643 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M13036 636 538 1213 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M13037 GD 586 644 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13038 644 689 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13039 GD 536 644 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M13040 644 642 643 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M13041 643 536 1218 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M13042 1218 689 1217 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M13043 1217 586 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13044 GD 586 641 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M13045 641 536 642 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M13046 642 586 1216 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M13047 1216 689 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13048 GD 689 641 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M13049 640 636 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M13050 639 637 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M13051 775 722 1284 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M13052 1284 774 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M13053 774 773 1283 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13054 1283 722 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13055 GD 659 773 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13056 1288 780 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M13057 780 779 1287 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13058 1287 722 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13059 GD 633 779 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13060 S_6 778 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13061 778 722 1286 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M13062 1286 777 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M13063 777 776 1285 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13064 1285 722 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13065 GD 700 776 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13066 S_5 775 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13067 S_1 763 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13068 763 745 1276 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M13069 1276 762 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M13070 762 761 1275 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13071 1275 745 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13072 GD 729 761 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13073 S_4 772 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13074 S_0 760 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13075 772 745 1282 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M13076 760 745 1274 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M13077 1282 771 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M13078 1274 759 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M13079 771 770 1281 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13080 759 758 1273 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13081 1281 745 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13082 1273 745 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13083 GD 741 770 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13084 GD 725 758 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13085 S_3 769 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13086 769 745 1280 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M13087 1280 768 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M13088 768 767 1279 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13089 1279 745 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13090 GD 737 767 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13091 S_2 766 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13092 766 745 1278 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M13093 1278 765 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M13094 765 764 1277 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13095 1277 745 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13096 GD 733 764 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13097 GD 721 745 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13098 GD 739 1261 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M13099 1261 719 738 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M13100 GD 738 737 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13101 736 706 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M13102 GD 719 1260 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M13103 1260 736 735 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M13104 GD 735 1259 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M13105 1259 719 734 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M13106 GD 734 733 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13107 732 705 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M13108 GD 719 1258 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M13109 1258 732 731 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M13110 GD 731 1257 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M13111 1257 719 730 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M13112 GD 730 729 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13113 744 655 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M13114 728 1 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M13115 GD 719 1264 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M13116 GD 719 1256 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M13117 1264 744 743 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M13118 1256 728 727 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M13119 GD 743 1263 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M13120 GD 727 1255 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M13121 1263 719 742 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M13122 1255 719 726 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M13123 GD 742 741 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13124 GD 726 725 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13125 740 664 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M13126 GD 719 1262 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M13127 1262 740 739 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M13128 1241 661 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13129 GD 661 696 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M13130 701 697 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M13131 700 698 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M13132 GD 588 699 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13133 699 661 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13134 GD 472 699 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M13135 699 697 698 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M13136 698 472 1243 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M13137 1243 661 1242 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M13138 1242 588 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13139 GD 588 696 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M13140 696 472 697 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M13141 697 588 1241 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M13142 694 692 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M13143 GD 537 693 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13144 693 634 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13145 GD 529 693 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M13146 693 691 692 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M13147 692 529 1240 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M13148 1240 634 1239 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M13149 1239 537 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13150 GD 537 690 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M13151 690 529 691 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M13152 691 537 1238 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M13153 1238 634 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13154 GD 634 690 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M13155 661 660 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=190.350000844018E-15 PD=1.35000004775065E-6
+PS=1.62000003456342E-6 M=1
M13156 660 571 1223 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13157 1223 618 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M13158 GD 571 1222 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13159 1222 618 659 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13160 659 658 1221 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=72.8999990256586E-15 PD=629.999988177588E-9
+PS=539.999973625527E-9 M=1
M13161 1221 657 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=166.049994392535E-15 PD=539.999973625527E-9
+PS=1.4400000054593E-6 M=1
M13162 658 571 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13163 657 618 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13164 630 523 1210 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=60.7500025761806E-15 PD=1.25999997635518E-6
+PS=449.999987495175E-9 M=1
M13165 1210 701 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13166 GD 701 629 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=166.049994392535E-15 PD=720.000002729648E-9
+PS=1.4400000054593E-6 M=1
M13167 634 630 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=153.900004719321E-15 PD=1.97999997908482E-6
+PS=1.35000004775065E-6 M=1
M13168 633 631 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=238.950000194457E-15 AS=89.0999988091383E-15 PD=1.97999997908482E-6
+PS=629.999988177588E-9 M=1
M13169 GD 523 632 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13170 632 701 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13171 GD 489 632 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=137.700004935841E-15 PD=629.999988177588E-9
+PS=989.999989542412E-9 M=1
M13172 632 630 631 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=174.150001060538E-15 PD=989.999989542412E-9
+PS=1.25999997635518E-6 M=1
M13173 631 489 1212 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=66.8249974127878E-15 PD=1.25999997635518E-6
+PS=494.999994771206E-9 M=1
M13174 1212 701 1211 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=60.7500025761806E-15 PD=494.999994771206E-9
+PS=449.999987495175E-9 M=1
M13175 1211 523 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=101.25000203488E-15 PD=449.999987495175E-9
+PS=720.000002729648E-9 M=1
M13176 GD 523 629 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=89.0999988091383E-15 PD=720.000002729648E-9
+PS=629.999988177588E-9 M=1
M13177 629 489 630 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=174.150001060538E-15 PD=629.999988177588E-9
+PS=1.25999997635518E-6 M=1
M13178 GD 593 606 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13179 593 CLK_EN GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13180 GD 524 1176 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=226.799996968716E-15 AS=72.8999990256586E-15 PD=1.89000002137618E-6
+PS=539.999973625527E-9 M=1
M13181 1176 542 566 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=251.100003420199E-15 PD=539.999973625527E-9
+PS=2.06999993679347E-6 M=1
M13182 GD 593 555 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13183 GD 555 451 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13184 GD 409 1097 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M13185 1097 387 408 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M13186 GD 408 407 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13187 406 B_0 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M13188 GD 387 1096 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M13189 1096 406 405 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M13190 GD 405 1095 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M13191 1095 387 404 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M13192 GD 404 403 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13193 GD 417 1101 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M13194 1101 387 416 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M13195 GD 416 415 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13196 414 B_2 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M13197 GD 387 1100 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M13198 1100 414 413 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M13199 GD 413 1099 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=214.649993742974E-15 AS=60.7500025761806E-15 PD=1.7999999499807E-6
+PS=449.999987495175E-9 M=1
M13200 1099 387 412 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=166.049994392535E-15 PD=449.999987495175E-9
+PS=1.4400000054593E-6 M=1
M13201 GD 412 411 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13202 410 B_1 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=89.0999988091383E-15 PD=1.62000003456342E-6
+PS=629.999988177588E-9 M=1
M13203 GD 387 1098 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M13204 1098 410 409 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M13205 GD 451 388 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13206 387 451 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13207 369 451 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13208 1060 336 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M13209 336 335 1059 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13210 1059 369 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13211 GD A_7 335 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13212 348 347 1065 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13213 1065 369 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13214 GD A_4 347 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13215 346 345 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13216 345 369 1064 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M13217 1064 344 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M13218 344 343 1063 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13219 1063 369 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13220 GD A_5 343 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13221 342 341 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13222 341 369 1062 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M13223 1062 340 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M13224 340 339 1061 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13225 1061 369 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M13226 GD A_6 339 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1
M13227 338 337 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13228 337 369 1060 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M13229 333 245 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M13230 GD 245 1058 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M13231 1058 235 334 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M13232 334 282 333 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M13233 333 235 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1
M13234 GD 235 1057 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M13235 1057 245 1056 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M13236 1056 282 332 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M13237 332 334 331 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M13238 331 282 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M13239 GD 245 331 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13240 331 235 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13241 GD 332 330 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M13242 GD 334 329 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M13243 326 244 1054 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=48.5999993504391E-15 PD=629.999988177588E-9
+PS=360.000001364824E-9 M=1
M13244 1054 101 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M13245 GD 244 1053 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M13246 1053 101 325 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=153.900004719321E-15 PD=360.000001364824E-9
+PS=1.35000004775065E-6 M=1
M13247 GD 325 324 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=190.350000844018E-15 AS=153.900004719321E-15 PD=1.62000003456342E-6
+PS=1.35000004775065E-6 M=1
M13248 GD 244 328 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13249 GD 101 327 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M13250 GD 328 1055 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=72.8999990256586E-15 PD=1.4400000054593E-6
+PS=539.999973625527E-9 M=1
M13251 1055 327 326 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=72.8999990256586E-15 AS=89.0999988091383E-15 PD=539.999973625527E-9
+PS=629.999988177588E-9 M=1
M13252 GD 222 1038 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M13253 1038 255 1037 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=66.8249974127878E-15 PD=449.999987495175E-9
+PS=494.999994771206E-9 M=1
M13254 1037 248 295 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M13255 295 297 294 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M13256 294 248 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M13257 GD 255 294 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13258 294 222 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13259 GD 295 293 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M13260 GD 297 292 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M13261 1040 254 301 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=66.8249974127878E-15 AS=174.150001060538E-15 PD=494.999994771206E-9
+PS=1.25999997635518E-6 M=1
M13262 301 303 300 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=137.700004935841E-15 PD=1.25999997635518E-6
+PS=989.999989542412E-9 M=1
M13263 300 254 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=137.700004935841E-15 AS=89.0999988091383E-15 PD=989.999989542412E-9
+PS=629.999988177588E-9 M=1
M13264 GD 317 300 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13265 300 261 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=89.0999988091383E-15 PD=629.999988177588E-9
+PS=629.999988177588E-9 M=1
M13266 GD 301 299 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=238.950000194457E-15 PD=629.999988177588E-9
+PS=1.97999997908482E-6 M=1
M13267 GD 303 298 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=238.950000194457E-15 PD=1.35000004775065E-6
+PS=1.97999997908482E-6 M=1
M13268 296 255 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=101.25000203488E-15 PD=1.4400000054593E-6
+PS=720.000002729648E-9 M=1
M13269 GD 255 1039 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=101.25000203488E-15 AS=60.7500025761806E-15 PD=720.000002729648E-9
+PS=449.999987495175E-9 M=1
M13270 1039 222 297 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=174.150001060538E-15 PD=449.999987495175E-9
+PS=1.25999997635518E-6 M=1
M13271 297 248 296 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=174.150001060538E-15 AS=89.0999988091383E-15 PD=1.25999997635518E-6
+PS=629.999988177588E-9 M=1
M13272 296 222 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=101.25000203488E-15 PD=629.999988177588E-9
+PS=720.000002729648E-9 M=1

.lib "$CDK_DIR/models/hspice/public/publicModel/tsmc18dP" PMOS
.lib "$CDK_DIR/models/hspice/public/publicModel/tsmc18dN" NMOS

* INCLUDE FILES

* END OF NETLIST
.TEMP    25.0000
.TRAN  1.00000E-09 60.00000E-08 START=  0.0000
*.OP
*.save
*.OPTION  INGOLD=2 ARTIST=2 PSF=2
*+        PROBE=0
vGD GD 0 DC=0v
vVD VD 0 DC=1.8v
vclk clk 0 pulse 0v 1.8v 1n 0.1n 0.1n 1.5n 3n
.END
