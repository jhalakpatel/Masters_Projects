* # FILE NAME: /HOME/ECEGRID/A/559MG3/CADENCE/SIMULATION/FF_POSITIVE_EDGE/
* HSPICES/EXTRACTED/NETLIST/FF_POSITIVE_EDGE.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON NOV 25 23:04:49 2014

* FILE NAME: PROJ_LIB_FF_POSITIVE_EDGE_EXTRACTED.S.
* SUBCIRCUIT FOR CELL: FF_POSITIVE_EDGE.
* GENERATED FOR: HSPICES.
* GENERATED ON NOV 25 23:04:49 2014.

C12 GD 3  91.1412E-18 M=1.0
C13 GD 2  76.2129E-18 M=1.0
C14 GD 1  70.713E-18 M=1.0
C15 CLK GD  148.4973E-18 M=1.0
C16 CLK VD  26.7138E-18 M=1.0
C17 D_IN GD  84.0699E-18 M=1.0
C18 1 2  171.7443E-18 M=1.0
C19 GD 3  202.6413E-18 M=1.0
C20 GD 2  226.8738E-18 M=1.0
C21 GD 1  250.7832E-18 M=1.0
C22 Q_OUT GD  183.8277E-18 M=1.0
C23 VD 3  30.4272E-18 M=1.0
C24 VD 2  30.4272E-18 M=1.0
C25 VD 1  45.4923E-18 M=1.0
C26 VD Q_OUT  30.4272E-18 M=1.0
C27 CLK 1  75.2328E-18 M=1.0
C28 CLK GD  75.66075E-18 M=1.0
C29 D_IN 1  75.2328E-18 M=1.0
C30 D_IN VD  20.4129E-18 M=1.0
C31 CLK 2  74.9664E-18 M=1.0
C32 CLK 1  192.0096E-18 M=1.0
C33 CLK GD  624.123E-18 M=1.0
C34 D_IN CLK  42.0768E-18 M=1.0
M35 Q_OUT 3 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=510.300027060928E-15 PD=1.70999999227206E-6
+PS=2.06999993679347E-6 M=1
M36 3 2 VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=364.499988352029E-15 PD=1.70999999227206E-6
+PS=1.70999999227206E-6 M=1
M37 2 CLK VD VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=364.499988352029E-15 AS=218.700003853239E-15 PD=1.70999999227206E-6
+PS=539.999973625527E-9 M=1
M38 VD D_IN 11 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=218.700003853239E-15 AS=182.249994176015E-15 PD=539.999973625527E-9
+PS=449.999987495175E-9 M=1
M39 11 CLK 1 VD  TSMC18DP  L=180.000000682412E-9 W=810.000017281709E-9
+AD=182.249994176015E-15 AS=583.199992205269E-15 PD=449.999987495175E-9
+PS=2.25000007958442E-6 M=1
M40 Q_OUT 3 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=153.900004719321E-15 PD=1.35000004775065E-6
+PS=1.35000004775065E-6 M=1
M41 3 CLK 5 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=166.049994392535E-15 AS=60.7500025761806E-15 PD=1.4400000054593E-6
+PS=449.999987495175E-9 M=1
M42 5 2 GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=60.7500025761806E-15 AS=214.649993742974E-15 PD=449.999987495175E-9
+PS=1.7999999499807E-6 M=1
M43 2 1 4 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=153.900004719321E-15 AS=48.5999993504391E-15 PD=1.35000004775065E-6
+PS=360.000001364824E-9 M=1
M44 4 CLK GD GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=48.5999993504391E-15 AS=89.0999988091383E-15 PD=360.000001364824E-9
+PS=629.999988177588E-9 M=1
M45 GD D_IN 1 GD  TSMC18DN  L=180.000000682412E-9 W=269.999986812763E-9
+AD=89.0999988091383E-15 AS=190.350000844018E-15 PD=629.999988177588E-9
+PS=1.62000003456342E-6 M=1

.lib "$CDK_DIR/models/hspice/public/publicModel/tsmc18dP" PMOS
.lib "$CDK_DIR/models/hspice/public/publicModel/tsmc18dN" NMOS

* INCLUDE FILES

* END OF NETLIST
*.TRAN  1.00000E-09 6.00000E-08 START=  0.0000
.TEMP    25.0000
*.OP
*.save
*.OPTION  INGOLD=2 ARTIST=2 PSF=2
*+        PROBE=0
*vD_IN D_IN 0 pulse 0v 1.8v 1n 0.1n 0.1n 5n 10n
vGD GD 0 DC=0v
vVD VD 0 DC=2.5v
vclk clk 0 pulse 0v 2.5v 1n 0.1n 0.1n 5n 10n
.END
