simulator( 'hspiceS )
